# OrCAD Capture schematic PROC180E1_SCH.DSN, sheets 36 to 38 of 59

## Sheets
36 24. LPDDR4 INTERFACE: size C; title: SOC LPDDR4 INTERFACE
37 26. eMMC FLASH: size C; title: eMMC  INTERFACE
38 27. SD CARD INTERFACE: size C; title: SD CARD INTERFACE

## Parts
sheet 24. LPDDR4 INTERFACE
C237  10uF  [CAP0402_0-75]
C238  10uF  [CAP0402_0-75]
C239  10uF  [CAP0402_0-75]
C539  0.1uF  [CAP0201_0-5]
C540  1000pF  [CAP0201_0-5]
C541  0.01uF  [CAP0201_0-5]
C542  0.1uF  [CAP0201_0-5]
C543  0.01uF  [CAP0201_0-5]
C544  1000pF  [CAP0201_0-5]
C545  0.01uF  [CAP0201_0-5]
C548  0.1uF  [CAP0201_0-5]
C549  0.1uF  [CAP0201_0-5]
C550  0.1uF  [CAP0201_0-5]
C551  0.1uF  [CAP0201_0-5]
C552  0.1uF  [CAP0201_0-5]
C553  0.1uF  [CAP0201_0-5]
C554  0.1uF  [CAP0201_0-5]
C556  0.1uF  [CAP0201_0-5]
C557  0.1uF  [CAP0201_0-5]
C558  0.1uF  [CAP0201_0-5]
C562  0.1uF  [CAP0201_0-5]
C563  0.1uF  [CAP0201_0-5]
C564  0.1uF  [CAP0201_0-5]
C566  0.1uF  [CAP0201_0-5]
C567  0.1uF  [CAP0201_0-5]
C568  0.1uF  [CAP0201_0-5]
C569  0.1uF  [CAP0201_0-5]
C570  1000pF  [CAP0201_0-5]
C571  1000pF  [CAP0201_0-5]
C573  0.1uF  [CAP0201_0-5]
C577  0.1uF  [CAP0201_0-5]
C578  0.1uF  [CAP0201_0-5]
C579  0.1uF  [CAP0201_0-5]
C580  0.1uF  [CAP0201_0-5]
C581  1000pF  [CAP0201_0-5]
C582  0.1uF  [CAP0201_0-5]
C583  1000pF  [CAP0201_0-5]
C584  0.01uF  [CAP0201_0-5]
C585  0.1uF  [CAP0201_0-5]
C586  0.1uF  [CAP0201_0-5]
C587  0.01uF  [CAP0201_0-5]
C588  0.1uF  [CAP0201_0-5]
C589  0.1uF  [CAP0201_0-5]
C590  10uF  [CAP0402_0-75]
C591  0.1uF  [CAP0201_0-5]
C594  0.01uF  [CAP0201_0-5]
C595  10uF  [CAP0402_0-75]
C596  10uF  [CAP0402_0-75]
FL16  120E  [EMIFIL_BLM15A_0402_0-6]
R312  240E_1%  [RES0201_0-5]
R315  240E_1%  [RES0201_0-5]
R573  240E_1%  [RES0201_0-5]
R588  10K  [RES0402_0-5]
R589  2.2K  [RES0402_0-5]
R594  2.2K  [RES0402_0-5]
R595  2.2K  [RES0402_0-5]
U58  MT53E1G32D2FW-046 IT:C  [WFBGA200_MT53E2G32D4DE_400X570_1-2]  (sections A,B)
sheet 26. eMMC FLASH
C146  0.1uF  [CAP0402_0-75]
C498  0.1uF  [CAP0402_0-75]
C503  0.1uF  [CAP0402_0-75]
C504  2.2uF  [CAP0402_0-75]
C514  0.1uF  [CAP0402_0-75]
C518  2.2uF  [CAP0402_0-75]
C520  0.1uF  [CAP0402_0-75]
C521  0.1uF  [CAP0402_0-75]
C527  1uF  [CAP0201_0-5]
R115  100K  [RES0201_0-5]
R116  0E  [RES0201_0-5]
R117  10K  [RES0201_0-5]
R167  0E  [RES0402_0-5]
R168  0E  [RES0402_0-5]
R169  0E  [RES0402_0-5]
R182  0E  [RES0402_0-5]
R183  0E  [RES0402_0-5]
R184  22E  [RES0402_0-5]
R185  22E  [RES0402_0-5]
R202  10K  [RES0201_0-5]
R207  0E  [RES0201_0-5]
R262  10K  [RES0201_0-5]
R263  10K  [RES0201_0-5]
R264  10K  [RES0201_0-5]
R266  10K  [RES0201_0-5]
R267  10K  [RES0201_0-5]
R269  10K  [RES0201_0-5]
R270  10K  [RES0201_0-5]
R275  10K  [RES0201_0-5]
R496  0E  [RES0402_0-5]
R558  0E  [RES0201_0-5]
R561  10K  [RES0201_0-5]
R562  10K  [RES0201_0-5]
R565  10K  [RES0201_0-5]
R575  10K  [RES0201_0-5]
TP116  TP20_SMD  [TP20_SMD]
U26  SN74LVC1G08DBVRE4  [SOT23-5]
U49  MTFC32GAZAQHD-IT  [VFBGA153_19-68_460X520_0-9]
sheet 27. SD CARD INTERFACE
C28  0.1uF  [CAP0402_0-75]
C33  4.7uF  [CAP0402_0-75]
C37  0.1uF  [CAP0402_0-75]
C69  1uF  [CAP0201_0-5]
C70  220pF  [CAP0402_0-75]
C88  2.2uF  [CAP0402_0-75]
C93  0.1uF  [CAP0402_0-75]
C102  0.1uF  [CAP0402_0-75]
C103  0.1uF  [CAP0402_0-75]
FL4  120E  [EMIFIL_BLM15A_0402_0-6]
J26  CON_SDCARD9_MEM2052-00-195-00-A  [CON_SD9_MEM2052-00-195-00_S_R_S_2]
R17  10K  [RES0201_0-5]
R18  10K  [RES0201_0-5]
R19  0E  [RES0201_0-5]
R21  0E  [RES0201_0-5]
R54  10K  [RES0201_0-5]
R55  10K  [RES0201_0-5]
R57  10K  [RES0201_0-5]
R64  10K  [RES0201_0-5]
R65  10K  [RES0201_0-5]
R66  10K  [RES0201_0-5]
R70  10K  [RES0201_0-5]
TP21  TP20_SMD  [TP20_SMD]
U2  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]
U4  TPS22918DBVR  [SOT23-6]
U10  TPD6E001RSER  [UQFN10_19-68_80X60_0-6]
U12  TPD2E001DRLR  [SOT553-5_0-6]
sheet 30. SOC PERIPHERALS 3
U47  XAM62D24AVGHIANF  [FBGA484_31-49_710X710_2-7]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N,O,P,Q)

## Library data of the parts
C237-C239 C590 C595 C596 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C539 C542 C548-C554 C556-C558 C562-C564 C566-C569 C573 C577-C580 C582 C585 C586 C588 C589 C591 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C540 C544 C570 C571 C581 C583 = CAP: CAP CERAMIC 1000pF 10V 10% X7R 0201; Chkd/date: VASANTHA/010117; Crtd /date: MAZHAR/160807; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 0201ZC102KAT2A-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 0201ZC102KAT2A; Mistral Part No: 120009030143-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: V8TS; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 10V; Wattage: NA; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_MLC.PDF
C541 C543 C545 C584 C587 C594 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT033R61E103KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033R61E103KE01D; Mistral Part No: 120021120019-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033R61E103KE01.PDF
FL4 FL16 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 2A 0402; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM15PX121SZ1B; Mistral Part No: 130021120017-R; Package: 0402; Part_type: INDUCTOR; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM-SER.PDF
R312 R315 R573 = RESISTOR: RES 240E 1/20W 1% 0201; Chkd/date: VASANTHA/251116; Crtd /date: MANIRAJA/241116; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: YAG2528CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201FR-07240RL; Mistral Part No: 110016110007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: ALL_DATA_NANO_SOM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 1%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R588 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R589 R594 R595 = RESISTOR: RES 2.2K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: BAVISH/021210; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-2.2KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-072K2L; Mistral Part No: 110010120018-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: TE4; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U58 = MT53D1024M32D4DT_VFBGA200: IC 4GB AUTO LPDDR4/LPDDR4x SDRAM TFBGA200; Chkd/date: PRADEEP/081223; Crtd /date: PRADEEP/081223; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.14MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCMEMORY_Library.schlib; Mfr_name: MICRON; Mistral Part No: 141123120002-R; Package: TFBGA200; Part_type: ICS\DIGITAL\MEMORY; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+95°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\MEMORY\MT53EX-A-AUTO-SER.PDF
C28 C37 C93 C102 C103 C146 C498 C503 C514 C520 C521 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C88 C504 C518 = CAP: CAP CERAMIC 2.2uF 25V 10% X5R AUTO 0402; Chkd/date: MANIRAJA/240920; Crtd /date: ALVY/240920; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-12267-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R61E225KE13D; Mistral Part No: 120020090019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: ECU_RO; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R61E225KE13.PDF
C69 C527 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
R115 = RESISTOR: RES 100K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-100KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-07100KL; Mistral Part No: 110009030176-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R19 R21 R116 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R17 R18 R54 R55 R57 R64-R66 R70 R117 R202 R262-R264 R266 R267 R269 R270 R275 R561 R562 R565 R575 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R167-R169 R182 R183 R496 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R184 R185 = RESISTOR: RES 22E 1/10W 5% 0402; Chkd/date: VASANTHA/060117; Crtd /date: MAZHAR/120505; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P22JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ220X; Mistral Part No: 110009030515-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: EPDA_CORE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R207 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R558 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_22E_1%_22E_1%; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP21 TP116 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U26 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF
U49 = MTFC16GAPALBH_TFBGA153: IC 32GB e-MMC MEMORY VFBGA153; Chkd/date: PRAVEEN/010922; Crtd /date: PRAVEEN/010922; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 557-MTFC32GAZAQHD-IT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCMEMORY_Library.schlib; Mfr_name: MICRON; Mistral Part No: 141122090001-R; Package: VFBGA153; Part_type: ICS\DIGITAL\MEMORY; Project: J7AHP_SK_BRD; RoHS: RoHS; Temperature: -40°C+95°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\MEMORY\MTFC64GAZAQHD-IT.PDF
C33 = CAP: CAP CERAMIC 4.7uF 10V 20% X5R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R61A475ME13; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R61A475ME13D; Mistral Part No: 120021020032-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 1.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R61A475ME13.PDF
C70 = CAP: CAP CERAMIC 220pF 50V 5% C0G(NP0) AUTO 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT1555C1H221JA02; Mistral Part No: 120022060024-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 50V; Wattage: NA; Weight: 3.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT1555C1H221JA02.PDF
J26 = CON_SDCARD9_MEM2075-00-140: CON MICROSD CARD 9POS FEMALE RT SMD; Chkd/date: PRADEEP/1812023; Crtd /date: TAMILARASU/181223; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 2073-MEM2052-00-195-00-ACT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.95MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: GCT; Mfr_part_number: MEM2052-00-195-00-A; Mistral Part No: 150023120024-R; Package: SMD; Part_type: CONNECTOR\MEMORY CARD; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\MEM2052-00-195-00-A.PDF
U2 = SN74LVC1G11DCKR_SC70-6: IC SINGLE 3-INPUT POSITIVE-AND GATE SON6; Chkd/date: MANIRAJA/270121; Crtd /date: ALVY/270121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30120-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_GATE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141021010013-R; Package: SON6; Part_type: ICS\DIGITAL\GATES; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G_NOV16.PDF
U4 = TPS22918DBVR_SOT23-6: IC ON RESISTANCE LOAD SWITCH SOT23-6; Automotive Alternate_mfr_name: TEXAS INSTRUMENTS; Automotive Alternate_mfr_part_number: TPS22918TDBVRQ1; Chkd/date: VASANTHA/130516; Crtd /date: VASANTHA/130516; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: TPS22918DBVR-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142016050007-R; Part_type: ICS\POWER; Project: TMDXCSK8127; RoHS: RoHS; Temperature: -40°C to 105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\TPS22918DBV.PDF
U10 = TPD6E001RSE_UQFN10: IC 6CH ESD-PROTECTION ARRAY UQFN10; Chkd/date: USMAN/070612; Crtd /date: BAVISH/160811; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-21888-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; IBISSP_MODLES: Y:\MIS_DATABASE\IBIS\ICs\INTERFACE\TPD6E001RSE.IBS; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011080020-R; Package: UQFN10; Part_type: ICS\INTERFACE; Project: DM385EVM_BASE-BOARD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD6E001.PDF
U12 = TPD2E001DRLR_SOT-5: IC ESD-PROTECTION DIODE ARRAYS SOT-5; Chkd/date: NAVEED/150714; Crtd /date: MUDDU/250510; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-21883-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140110060007-R; Package: SOT-5; Part_type: ICS\ANALOG\ACTIVE FILTER; Project: CENTAURUS; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 2.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\MISC\TPD2E001DRLR.PDF
U47 = AM62D_EVM_SOC_FCBGA484: IC AM62D EVM SoC MICROPROCESSOR FCBGA484; Chkd/date: PRADEEP/010424; Crtd /date: PRADEEP/010424; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.65MM; Library Ref: AM62D_EVM_SoC_FCBGA484; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141224040001-R; Package: FCBGA484; Part_type: ICS\DIGITAL\MICROPROCESSOR; Project: AM62D_EVM; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\MICROCONTROLLER\AM62A_SK_EVM.PDF

## Nets
DGND: C28.2 C33.1 C37.2 C69.2 C70.2 C88.1 C93.1 C102.1 C103.1 C146.2 C237.2 C238.2 C239.2 C498.2 C503.2 C504.2 C514.2 C518.2 C520.2 C521.2 C527.2 C539.2 C540.2 C541.1 C542.2 C543.1 C544.2 C545.1 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C556.2 C557.2 C558.2 C562.2 C563.2 C564.2 C566.2 C567.2 C568.2 C569.2 C570.2 C571.2 C573.2 C577.2 C578.2 C579.2 C580.2 C581.2 C582.2 C583.2 C584.1 C585.2 C586.2 C587.1 C588.2 C589.2 C590.2 C591.2 C594.1 C595.2 C596.2 J26.6(VSS) J26.SH1 J26.SH2 J26.SH3 J26.SH4 R202.2 R561.2 R562.2 R573.2 R588.1 U2.2(GND) U4.2(GND) U10.5(GND) U12.4(GND) U26.3(GND) U49.A6(VSS) U49.C4(VSSQ) U49.E7(VSS) U49.G5(VSS) U49.H10(VSS) U49.J5(VSS) U49.K8(VSS) U49.N2(VSSQ) U49.N5(VSSQ) U49.P4(VSSQ) U49.P6(VSSQ) U58.A3(VSS) U58.A10(VSS) U58.AB3(VSS) U58.AB5(VSS) U58.AB8(VSS) U58.AB10(VSS) U58.C1(VSS) U58.C5(VSS) U58.C8(VSS) U58.C12(VSS) U58.D2(VSS) U58.D4(VSS) U58.D9(VSS) U58.D11(VSS) U58.E1(VSS) U58.E5(VSS) U58.E8(VSS) U58.E12(VSS) U58.G1(VSS) U58.G3(VSS) U58.G5(VSS) U58.G8(VSS) U58.G10(VSS) U58.G12(VSS) U58.J1(VSS) U58.J3(VSS) U58.J10(VSS) U58.J12(VSS) U58.K2(VSS) U58.K4(VSS) U58.K9(VSS) U58.K11(VSS) U58.N2(VSS) U58.N4(VSS) U58.N9(VSS) U58.N11(VSS) U58.P1(VSS) U58.P3(VSS) U58.P10(VSS) U58.P12(VSS) U58.T1(VSS) U58.T3(VSS) U58.T5(VSS) U58.T8(VSS) U58.T10(VSS) U58.T12(VSS) U58.V1(VSS) U58.V5(VSS) U58.V8(VSS) U58.V12(VSS) U58.W2(VSS) U58.W4(VSS) U58.W9(VSS) U58.W11(VSS) U58.Y1(VSS) U58.Y5(VSS) U58.Y8(VSS) U58.Y12(VSS) ; also on sheet 1 2 3 4 5 6 7 8 9 10 12 13 14 16 17 18 19 20 21 22 31 32 33 34 35 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58
VCC1V8_SYS: C102.2 C146.1 C503.1 C514.1 C518.1 R70.2 R117.1 R262.1 R263.1 R264.1 R266.1 R267.1 R269.1 R270.1 R275.1 R565.1 R575.1 U12.1(VCC) U26.5(VCC) U49.C6(VCCQ) U49.M4(VCCQ) U49.N4(VCCQ) U49.P3(VCCQ) U49.P5(VCCQ) ; also on sheet 1 2 4 6 7 10 20 21 22 33 39 43 49 50 52 53 54 55 56 57 58
VCC_3V3_SYS: C28.1 C33.2 C37.1 C498.1 C504.1 C520.1 R17.2 R18.2 R115.1 U2.5(VCC) U4.1(VIN) U49.E6(VCC) U49.F5(VCC) U49.J10(VCC) U49.K9(VCC) ; also on sheet 1 2 3 6 10 14 17 18 19 20 22 31 33 40 41 42 45 46 48 49 50 51 52 53 54 55 56 57 58
VDD1_LPDDR4_1V8: C237.1 C539.1 C543.2 C551.1 C554.1 C571.1 C578.1 C581.1 C588.1 C591.1 C594.2 C596.1 FL16.2 U58.F1(VDD1) U58.F12(VDD1) U58.G4(VDD1) U58.G9(VDD1) U58.T4(VDD1) U58.T9(VDD1) U58.U1(VDD1) U58.U12(VDD1)
VDD_LPDDR4: C238.1 C239.1 C540.1 C541.2 C542.1 C544.1 C545.2 C548.1 C549.1 C550.1 C552.1 C553.1 C556.1 C557.1 C558.1 C562.1 C563.1 C564.1 C566.1 C567.1 C568.1 C569.1 C570.1 C573.1 C577.1 C579.1 C580.1 C582.1 C583.1 C584.2 C585.1 C586.1 C587.2 C589.1 C590.1 C595.1 R312.1 R315.1 R589.2 R594.2 R595.2 U58.A4(VDD2) U58.A9(VDD2) U58.AA3(VDDQ) U58.AA5(VDDQ) U58.AA8(VDDQ) U58.AA10(VDDQ) U58.AB4(VDD2) U58.AB9(VDD2) U58.B3(VDDQ) U58.B5(VDDQ) U58.B8(VDDQ) U58.B10(VDDQ) U58.D1(VDDQ) U58.D5(VDDQ) U58.D8(VDDQ) U58.D12(VDDQ) U58.F3(VDDQ) U58.F5(VDD2) U58.F8(VDD2) U58.F10(VDDQ) U58.H1(VDD2) U58.H5(VDD2) U58.H8(VDD2) U58.H12(VDD2) U58.K1(VDD2) U58.K3(VDD2) U58.K10(VDD2) U58.K12(VDD2) U58.N1(VDD2) U58.N3(VDD2) U58.N10(VDD2) U58.N12(VDD2) U58.R1(VDD2) U58.R5(VDD2) U58.R8(VDD2) U58.R12(VDD2) U58.U3(VDDQ) U58.U5(VDD2) U58.U8(VDD2) U58.U10(VDDQ) U58.W1(VDDQ) U58.W5(VDDQ) U58.W8(VDDQ) U58.W12(VDDQ) ; also on sheet 33 34 35
VDD_MMC1: C69.1 FL4.1 U4.5(QOD) U4.6(VOUT)
VDD_MMC1_SD: C88.2 C93.2 FL4.2 J26.4(VDD) TP21.1(TP)
VDDIM: C521.1 C527.1 U49.C2(VDDIM)
VDDSHV_SDIO: C103.2 R54.2 R55.2 R57.2 R64.2 R65.2 R66.2 U10.10(VCC) ; also on sheet 13 14
VDDSHV_SDIO_EN: R19.1 ; also on sheet 14
CPLD_McASP1_AFSR: R169.2 ; also on sheet 20 54
CPLD_McASP1_AFSX: R182.2 ; also on sheet 20 54
eMMC_RSTn: R117.2 U26.4(Y) U49.K5(RST_N)
EXP1_McASP1_ACLKR: R185.2 ; also on sheet 54
EXP1_McASP1_ACLKX: R184.2 ; also on sheet 54
EXP1_McASP1_AXR0: R496.2 ; also on sheet 54
EXP1_McASP1_AXR1: R183.2 ; also on sheet 54
EXP1_McASP1_AXR2: R167.2 ; also on sheet 54
EXP1_McASP1_AXR3: R168.2 ; also on sheet 54
GPIO_eMMC_RSTn: R116.1 ; also on sheet 55
LPDDR4_CA0: U47.J5(DDR0_A0) U58.H2(CA0_A) U58.R2(CA0_B)
LPDDR4_CA1: U47.J2(DDR0_A1) U58.J2(CA1_A) U58.P2(CA1_B)
LPDDR4_CA2: U47.J4(DDR0_A2) U58.H9(CA2_A) U58.R9(CA2_B)
LPDDR4_CA3: U47.L4(DDR0_A3) U58.H10(CA3_A) U58.R10(CA3_B)
LPDDR4_CA4: U47.J1(DDR0_A4) U58.H11(CA4_A) U58.R11(CA4_B)
LPDDR4_CA5: U47.K5(DDR0_A5) U58.J11(CA5_A) U58.P11(CA5_B)
LPDDR4_CAL0: R573.1 U47.H6(DDR0_CAL0)
LPDDR4_CK_N: U47.L1(DDR0_CK0_N) U58.J9(CK_C_A) U58.P9(CK_C_B)
LPDDR4_CK_P: U47.M1(DDR0_CK0) U58.J8(CK_T_A) U58.P8(CK_T_B)
LPDDR4_CKE0: U47.P3(DDR0_CKE0) U58.J4(CKE0_A) U58.P4(CKE0_B)
LPDDR4_CKE1: U47.P5(DDR0_CKE1) U58.J5(CKE1_A) U58.P5(CKE1_B)
LPDDR4_CS0_A: U47.J6(DDR0_CS0_N) U58.H4(CS0_A)
LPDDR4_CS0_B: U47.M6(DDR0_RAS_N) U58.R4(CS0_B)
LPDDR4_CS1_A: U47.N4(DDR0_CS1_N) U58.H3(CS1_A)
LPDDR4_CS1_B: U47.M5(DDR0_CAS_N) U58.R3(CS1_B)
LPDDR4_DMI0: U47.C2(DDR0_DM0) U58.C3(DMI0_A)
LPDDR4_DMI1: U47.F3(DDR0_DM1) U58.C10(DMI1_A)
LPDDR4_DMI2: U47.U1(DDR0_DM2) U58.Y3(DMI0_B)
LPDDR4_DMI3: U47.W3(DDR0_DM3) U58.Y10(DMI1_B)
LPDDR4_DQ0: U47.A5(DDR0_DQ0) U58.B2(DQ0_A)
LPDDR4_DQ1: U47.B4(DDR0_DQ1) U58.C2(DQ1_A)
LPDDR4_DQ2: U47.B6(DDR0_DQ2) U58.E2(DQ2_A)
LPDDR4_DQ3: U47.D5(DDR0_DQ3) U58.F2(DQ3_A)
LPDDR4_DQ4: U47.C5(DDR0_DQ4) U58.F4(DQ4_A)
LPDDR4_DQ5: U47.C3(DDR0_DQ5) U58.E4(DQ5_A)
LPDDR4_DQ6: U47.B2(DDR0_DQ6) U58.C4(DQ6_A)
LPDDR4_DQ7: U47.A3(DDR0_DQ7) U58.B4(DQ7_A)
LPDDR4_DQ8: U47.E2(DDR0_DQ8) U58.B11(DQ8_A)
LPDDR4_DQ9: U47.F5(DDR0_DQ9) U58.C11(DQ9_A)
LPDDR4_DQ10: U47.E6(DDR0_DQ10) U58.E11(DQ10_A)
LPDDR4_DQ11: U47.G2(DDR0_DQ11) U58.F11(DQ11_A)
LPDDR4_DQ12: U47.G6(DDR0_DQ12) U58.F9(DQ12_A)
LPDDR4_DQ13: U47.G4(DDR0_DQ13) U58.E9(DQ13_A)
LPDDR4_DQ14: U47.E4(DDR0_DQ14) U58.C9(DQ14_A)
LPDDR4_DQ15: U47.D3(DDR0_DQ15) U58.B9(DQ15_A)
LPDDR4_DQ16: U47.T6(DDR0_DQ16) U58.AA2(DQ0_B)
LPDDR4_DQ17: U47.T4(DDR0_DQ17) U58.Y2(DQ1_B)
LPDDR4_DQ18: U47.U5(DDR0_DQ18) U58.V2(DQ2_B)
LPDDR4_DQ19: U47.R5(DDR0_DQ19) U58.U2(DQ3_B)
LPDDR4_DQ20: U47.P2(DDR0_DQ20) U58.U4(DQ4_B)
LPDDR4_DQ21: U47.R3(DDR0_DQ21) U58.V4(DQ5_B)
LPDDR4_DQ22: U47.T2(DDR0_DQ22) U58.Y4(DQ6_B)
LPDDR4_DQ23: U47.U3(DDR0_DQ23) U58.AA4(DQ7_B)
LPDDR4_DQ24: U47.Y2(DDR0_DQ24) U58.AA11(DQ8_B)
LPDDR4_DQ25: U47.V2(DDR0_DQ25) U58.Y11(DQ9_B)
LPDDR4_DQ26: U47.V4(DDR0_DQ26) U58.V11(DQ10_B)
LPDDR4_DQ27: U47.W5(DDR0_DQ27) U58.U11(DQ11_B)
LPDDR4_DQ28: U47.Y4(DDR0_DQ28) U58.U9(DQ12_B)
LPDDR4_DQ29: U47.AA3(DDR0_DQ29) U58.V9(DQ13_B)
LPDDR4_DQ30: U47.AA5(DDR0_DQ30) U58.Y9(DQ14_B)
LPDDR4_DQ31: U47.AB4(DDR0_DQ31) U58.AA9(DQ15_B)
LPDDR4_DQS0_N: U47.C1(DDR0_DQS0_N) U58.E3(DQS0_C_A)
LPDDR4_DQS0_P: U47.D1(DDR0_DQS0) U58.D3(DQS0_T_A)
LPDDR4_DQS1_N: U47.F1(DDR0_DQS1_N) U58.E10(DQS1_C_A)
LPDDR4_DQS1_P: U47.G1(DDR0_DQS1) U58.D10(DQS1_T_A)
LPDDR4_DQS2_N: U47.P1(DDR0_DQS2_N) U58.V3(DQS0_C_B)
LPDDR4_DQS2_P: U47.R1(DDR0_DQS2) U58.W3(DQS0_T_B)
LPDDR4_DQS3_N: U47.Y1(DDR0_DQS3_N) U58.V10(DQS1_C_B)
LPDDR4_DQS3_P: U47.W1(DDR0_DQS3) U58.W10(DQS1_T_B)
LPDDR4_ODT_CA_A: R595.1 U58.G2(ODT_CA_A)
LPDDR4_ODT_CA_B: R594.1 U58.T2(ODT_CA_B)
LPDDR4_RESET_N: R588.2 R589.1 U47.P6(DDR0_RESET0_N) U58.T11(RESET_N)
LPDDR4_ZQ0: R315.2 U58.A5(ZQ0)
LPDDR4_ZQ1: R312.2 U58.A8(ZQ1)
MMC0_CLK: R558.1 R561.1 R565.2 U49.M6(CLK)
MMC1_CLK: J26.5(CLK) R54.1 R202.1 R207.1 U10.6(IO4)
MMC1_CLK_R: R207.2 U47.E22(MMC1_CLK)
MMC1_CMD: J26.3(CMD) R66.1 U10.1(IO1) U47.C21(MMC1_CMD)
MMC1_D0: J26.7(DAT0) R65.1 U10.8(IO6) U47.B22(MMC1_DAT0)
MMC1_D1: J26.8(DAT1) R57.1 U10.7(IO5) U47.D21(MMC1_DAT1)
MMC1_D2: J26.1(DAT2) R64.1 U10.2(IO2) U47.C22(MMC1_DAT2)
MMC1_D3: J26.2(CD/DAT3) R55.1 U10.3(IO3) U47.D22(MMC1_DAT3)
MMC1_SD_EN: R21.1 ; also on sheet 55
MMC1_SD_LS_EN: R17.1 R19.2 U2.4(Y) U4.3(ON)
MMC1_SDCD: J26.9(CD) R70.1 U12.5(IO2) U47.E18(MMC1_SDCD)
PORz_OUT: U2.6(C) ; also on sheet 10 40 41 43
RESETSTATz: U2.3(B) U26.2(B) ; also on sheet 5 10 39 40 41 43 49 55 56
SOC_DVDD1V8: FL16.1 ; also on sheet 33 34 35
SOC_GPIO1_49: U47.D18(MMC1_SDWP) ; also on sheet 55
SOC_MMC0_CLK: R558.2 U47.AB7(MMC0_CLK)
SOC_MMC0_CMD: R575.2 U47.Y6(MMC0_CMD) U49.M5(CMD)
SOC_MMC0_DAT0: R269.2 U47.AA6(MMC0_DAT0) U49.A3(DAT0)
SOC_MMC0_DAT1: R266.2 U47.AB6(MMC0_DAT1) U49.A4(DAT1)
SOC_MMC0_DAT2: R263.2 U47.Y7(MMC0_DAT2) U49.A5(DAT2)
SOC_MMC0_DAT3: R275.2 U47.AA7(MMC0_DAT3) U49.B2(DAT3)
SOC_MMC0_DAT4: R270.2 U47.Y8(MMC0_DAT4) U49.B3(DAT4)
SOC_MMC0_DAT5: R267.2 U47.W7(MMC0_DAT5) U49.B4(DAT5)
SOC_MMC0_DAT6: R264.2 U47.W9(MMC0_DAT6) U49.B5(DAT6)
SOC_MMC0_DAT7: R262.2 U47.AB8(MMC0_DAT7) U49.B6(DAT7)
N16848941: R115.2 R116.2 U26.1(A)
N16878497: R562.1 TP116.1(TP) U49.H5(DS)
N16880083: R18.1 R21.2 U2.1(A)
N24478126: C70.1 U4.4(CT)
N25026172: R169.1 U47.G22(MMC2_CMD)
N25026194: R185.1 U47.H22(MMC2_CLK)
N25124626: R496.1 U47.E20(MMC2_DAT0)
N25124643: R183.1 U47.F21(MMC2_DAT1)
N25124756: R182.1 U47.E21(MMC2_SDWP)
N25128465: R167.1 U47.F20(MMC2_DAT2)
N25128467: R168.1 U47.G21(MMC2_DAT3)
N26608860: R184.1 U47.F22(MMC2_SDCD)

Not connected (* = marked no-connect by the designer): U10 4(NC1)* 9(NC2)*; U12 2(NC)* 3(IO1)*; U47 F6(RSVD3)* G7(RSVD5)* H2(DDR0_A7)* H3(DDR0_BA1)* H5(DDR0_ODT0)* H7(DDR0_ALERT_N)* K2(DDR0_A10)* K3(DDR0_A6)* K6(DDR0_BA0)* L2(DDR0_A9)* L5(DDR0_A11)* L6(DDR0_A8)* M2(DDR0_A13)* M3(DDR0_A12)* N2(DDR0_PAR)* N3(DDR0_ODT1)* N5(DDR0_ACT_N)* N6(DDR0_WE_N)* P4(DDR0_BG0)* R7(DDR0_BG1)*; U49 A1(NC1)* A2(NC2)* A7(RFU1)* A8(NC3)* A9(NC4)* A10(NC5)* A11(NC6)* A12(NC7)* A13(NC8)* A14(NC9)* B1(NC10)* B7(NC11)* B8(NC12)* B9(NC13)* B10(NC14)* B11(NC15)* B12(NC16)* B13(NC17)* B14(NC18)* C1(NC19)* C3(NC20)* C5(NC21)* C7(NC22)* C8(NC23)* C9(NC24)* C10(NC25)* C11(NC26)* C12(NC27)* C13(NC28)* C14(NC29)* D1(NC30)* D2(NC31)* D3(NC32)* D4(NC33)* D12(NC34)* D13(NC35)* D14(NC36)* E1(NC37)* E2(NC38)* E3(NC39)* E5(RFU2)* E8(VSF1)* E9(VSF2)* E10(VSF3)* E12(NC40)* E13(NC41)* E14(NC42)* F1(NC43)* F2(NC44)* F3(NC45)* F10(VSF4)* F12(NC46)* F13(NC47)* F14(NC48)* G1(NC49)* G2(NC50)* G3(NC51)* G10(VSF5)* G12(NC52)* G13(NC53)* G14(NC54)* H1(NC55)* H2(NC56)* H3(NC57)* H12(NC58)* H13(NC59)* H14(NC60)* J1(NC61)* J2(NC62)* J3(NC63)* J12(NC64)* J13(NC65)* J14(NC66)* K1(NC67)* K2(NC68)* K3(NC69)* K6(RFU3)* K7(RFU4)* K10(VSF6)* K12(NC70)* K13(NC71)* K14(NC72)* L1(NC73)* L2(NC74)* L3(NC75)* L12(NC76)* L13(NC77)* L14(NC78)* M1(NC79)* M2(NC80)* M3(NC81)* M7(NC82)* M8(NC83)* M9(NC84)* M10(NC85)* M11(NC86)* M12(NC87)* M13(NC88)* M14(NC89)* N1(NC90)* N3(NC91)* N6(NC92)* N7(NC93)* N8(NC94)* N9(NC95)* N10(NC96)* N11(NC97)* N12(NC98)* N13(NC99)* N14(NC100)* P1(NC101)* P2(NC102)* P7(NC103)* P8(NC104)* P9(NC105)* P10(VSF7)* P11(NC106)* P12(NC107)* P13(NC108)* P14(NC109)*; U58 A1(DNU1)* A2(DNU2)* A11(DNU3)* A12(DNU4)* AA1(DNU7)* AA12(DNU8)* AB1(DNU9)* AB2(DNU10)* AB11(DNU11)* AB12(DNU12)* B1(DNU5)* B12(DNU6)* G11(NC1)* K5(NC2)* K8(NC3)* N5(NC4)* N8(NC5)*

## Notes on the sheets
sheet 36
- LPDDR4 DEVICE
- SOC LPDDR4 INTERFACE
- 80E
- 80E
- 80E
- 66E
- 80E
- Note: Pulldown is populated by default
- LPDDR4 POWER DECAPS
- VDD2_LPDDR4_1V1
- VDD2_LPDDR4_1V1
sheet 37
- eMMC INTERFACE
- eMMC FLASH
- External pulls for MMC0 are optional and DNI
  Internal Pulls are enabled by default
  for the MMC0 interface
- SOC - MMC Interface
- 0E provision on MMC0_CLK
  Recommended for signal integrity
- CAD Note: Place R321 and R343 near to the SoC (U18)
- eMMC FLASH RESET
- Design Note: eMMC_RSTn Active low
  s/w control
- The ANDing logic includes 2 functions
  1. I/O Level translation
  2. GPIO reset
  Verify I/O compatibility before optimizing
sheet 38
- SD CARD INTERFACE
- SD CARD RESET
- LOAD SWITCH
- Note: MMC1_CLK pullup is a DNI
- Place near SD Card Connector
