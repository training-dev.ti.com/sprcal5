# OrCAD Capture schematic PROC180E1_SCH.DSN, sheets 55 to 58 of 59

## Sheets
55 49. IO EXPANDER & LED: size C; title: IO EXPANDER & USER TEST LEDS
56 42. AUDIO MICROPHONE_LINE IN 1: size C; title: AUDIO - MICROPHONE/LINE IN 1
57 22. SOC RESET - 2: size C; title: SOC RESET - 2
58 47. CAN_INTERFACE: size C; title: CAN TRANSCEIVER

## Parts
sheet 22. SOC RESET - 2
C220  0.1uF  [CAP0201_0-5]
C425  0.1uF  [CAP0201_0-5]
C478  0.1uF  [CAP0201_0-5]
C489  0.1uF  [CAP0201_0-5]
C609  0.1uF  [CAP0201_0-5]
C622  0.1uF  [CAP0201_0-5]
D10  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
D11  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
D12  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
D14  TPD1E10B06DPYR  [DIO_DFN0402_0-5]
Q6  IRLML6401  [TO_SOT23-123]
Q7  IRLML6401  [TO_SOT23-123]
R250  0E  [RES0201_0-5]
R268  10K  [RES0201_0-5]
R274  0E  [RES0201_0-5]
R279  10K  [RES0201_0-5]
R375  10K  [RES0201_0-5]
R532  10K  [RES0201_0-5]
R546  4.7K  [RES0201_0-5]
R547  4.7K  [RES0201_0-5]
R550  10K  [RES0201_0-5]
R559  10K  [RES0201_0-5]
R615  10K  [RES0201_0-5]
SW4  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
SW5  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
SW6  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
SW8  7914G-1-000E  [SW4_100X216_200X200_SMD_4-2]
TP50  TP20_SMD  [TP20_SMD]
TP55  TP20_SMD  [TP20_SMD]
TP57  TP20_SMD  [TP20_SMD]
U50  SN74LVC3G17DCUR  [VSSOP8_19-68_85X95_0-9]
U98  SN74LVC3G17DCUR  [VSSOP8_19-68_85X95_0-9]
sheet 42. AUDIO MICROPHONE_LINE IN 1
C3  0.1uF  [CAP0402_0-75]
C15  2.2uF  [CAP0201_0-75]
C16  2.2uF  [CAP0201_0-75]
C17  2.2uF  [CAP0201_0-75]
C18  2.2uF  [CAP0201_0-75]
C63  1uF  [CAP0201_0-5]
C68  0.1uF  [CAP0201_0-5]
C81  0.1uF  [CAP0201_0-5]
C82  10uF  [CAP0402_0-75]
C84  0.1uF  [CAP0201_0-5]
C85  10uF  [CAP0402_0-75]
C87  1uF  [CAP0201_0-5]
C89  0.1uF  [CAP0201_0-5]
C92  0.1uF  [CAP0201_0-5]
C95  1uF  [CAP0201_0-5]
C96  2.2uF  [CAP0201_0-75]
C97  0.1uF  [CAP0201_0-5]
C98  2.2uF  [CAP0201_0-75]
C100  0.1uF  [CAP0402_0-75]
C109  0.1uF  [CAP0402_0-75]
C329  0.1uF  [CAP0402_0-75]
C331  2.2uF  [CAP0201_0-75]
C332  2.2uF  [CAP0201_0-75]
C333  2.2uF  [CAP0201_0-75]
C334  2.2uF  [CAP0201_0-75]
C378  10uF  [CAP0402_0-75]
C379  1uF  [CAP0805_1-5]
FL2  120E  [EMIFIL_BLM18P_0603_0-8]
J2  CON_AUDIOJACK6_STX-4235  [CON_AV6_STX-4235-3-3_S_R_T_26]  (sections A,B)
J7  HDR_1X2  [HDR_1X2_90120-0122_S_T_5-6]
L3  2.2uH  [IND0806]
R7  4.3K  [RES0402_0-5]
R8  4.3K  [RES0402_0-5]
R9  4.3K  [RES0402_0-5]
R10  4.3K  [RES0402_0-5]
R20  10K  [RES0201_0-5]
R22  10K  [RES0201_0-5]
R23  10K  [RES0201_0-5]
R26  10K  [RES0201_0-5]
R34  0E  [RES0201_0-5]
R38  0E  [RES0201_0-5]
R67  0E  [RES0603_0-75]
R68  10K  [RES0402_0-5]
R78  10K  [RES0402_0-5]
R84  0E  [RES0201_0-5]
R90  10K  [RES0402_0-5]
R405  4.3K  [RES0402_0-5]
R406  4.3K  [RES0402_0-5]
R407  4.3K  [RES0402_0-5]
R408  4.3K  [RES0402_0-5]
TP5  TP30_SMD  [TP30_SMD]
TP6  TP30_SMD  [TP30_SMD]
TP8  TP30_SMD  [TP30_SMD]
TP9  TP30_SMD  [TP30_SMD]
U7  PCM6240QRTVRQ1  [QFN32_19-68_200X200_0-8_EP3-6]
U14  SN74LVC1G08DBVRE4  [SOT23-5]
sheet 47. CAN_INTERFACE
C106  0.1uF  [CAP0402_0-75]
C107  4700pF  [CAP0402_0-75]
C113  0.1uF  [CAP0402_0-75]
C180  4700pF  [CAP0402_0-75]
C184  0.1uF  [CAP0402_0-75]
C185  0.1uF  [CAP0402_0-75]
J9  HDR_1X3  [HDR_1X3_100_S_T]
J15  HDR_1X3  [HDR_1X3_100_S_T]
R81  33E  [RES0402_0-5]
R82  0E  [RES0402_0-5]
R88  59E_1%  [RES0402_0-5]
R93  59E_1%  [RES0402_0-5]
R96  100K  [RES0201_0-5]
R102  0E  [RES0402_0-5]
R199  33E  [RES0402_0-5]
R208  59E_1%  [RES0402_0-5]
R215  59E_1%  [RES0402_0-5]
R222  100K  [RES0201_0-5]
R223  0E  [RES0402_0-5]
R273  0E  [RES0402_0-5]
U17  TCAN3413DR  [SOIC8_1-8]
U38  TCAN3413DR  [SOIC8_1-8]
sheet 49. IO EXPANDER & LED
C122  0.01uF  [CAP0201_0-5]
C126  0.01uF  [CAP0201_0-5]
C375  0.1uF  [CAP0201_0-5]
C376  0.1uF  [CAP0201_0-5]
C380  0.1uF  [CAP0201_0-5]
C381  0.1uF  [CAP0201_0-5]
LD1  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
LD10  150080VS75000  [LED_150080VS75000_80X50_SMD_0-8]
Q1  CSD16301Q2  [WSON6_CSD13202Q2_80X80_0-8]
Q5  CSD16301Q2  [WSON6_CSD13202Q2_80X80_0-8]
R94  10K  [RES0201_0-5]
R98  10K  [RES0201_0-5]
R106  10K  [RES0201_0-5]
R107  10K  [RES0201_0-5]
R108  0E  [RES0201_0-5]
R180  220E  [RES0402_0-5]
R203  10K  [RES0201_0-5]
R213  0E  [RES0402_0-5]
R427  0E  [RES0201_0-5]
R428  0E  [RES0201_0-5]
R434  10K  [RES0201_0-5]
R436  10K  [RES0402_0-5]
R440  220E  [RES0402_0-5]
R441  0E  [RES0402_0-5]
R442  10K  [RES0201_0-5]
U18  TCA6416ARTWR  [WQFN24_19-68_160X160]
U21  TCA6424ARGJR  [QFN32_19-68_200X200]
U78  TXB0304RUTR  [UQFN12_15-74_80X70]
U79  TXB0102DCUR  [VSSOP8_19-68_85X95_0-9]

## Library data of the parts
C220 C425 C478 C489 C609 C622 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
D10-D12 D14 = DIODE_SOD323: DIODE 1CH ESD PROTECTION X1SON2; Chkd/date: MANIRAJA/040420; Crtd /date: VASANTHA/181114; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30406-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 130014110022-R; Package: X1SON2; Part_type: DIODE; Project: GALILEO_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TPD1E10B06-SER.PDF
Q6 Q7 = MOSFET_IRLML6401TR: TRANSISTOR MOSFET P-CHANNEL SOT23-3; Chkd/date: SHREESHAIL/020206; Crtd /date: MAZHAR/040505; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: IRLML6401PBFCT-ND; Height: 1.11MM; Mfr_name: IRF; Mfr_part_number: IRLML6401TRPBF; Mistral Part No: 130009031213-P; Package: SOT23-3; Part_type: TRANSISTOR\MOSFET; Project: G4_SVGA; RoHS: Pb-Free; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\TRANSISTORS_FETS\IRLML6401.PDF
R34 R38 R84 R108 R250 R274 R427 R428 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R20 R22 R23 R26 R94 R98 R106 R107 R203 R268 R279 R375 R434 R442 R532 R550 R559 R615 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R546 R547 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
SW4-SW6 SW8 = 7914G-1-000E__7914G: SWITCH SPST-NO 4MM SQ SMD 7914G; Chkd/date: VASANTHA/271216; Crtd /date: BAVISH/051010; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 7914G-000ECT-ND; Height: 4.19MM; Library Ref: 7914G-1-000E _7914G; Mfr_name: BOURNS; Mistral Part No: 130015110004-R; Package: 7914G; Part_type: ELECTRO-MECHANICAL\SWITCH; Project: AAAUC; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\7914G-1-000E.PDF
TP50 TP55 TP57 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U50 U98 = SN74LVC3G17DCUR_VSSOP8: IC TRIPLE SCHMITT-TRIGGER BUFFER VSSOP8; Chkd/date: MANIRAJA/280917; Crtd /date: MANIRAJA/280917; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-18818-1-ND; Height: 0.90MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141017090019-R; Package: VSSOP8; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: TI_MAXIE_CPB; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 9.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\SN74LVC3G17.PDF
C3 C109 C329 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B3X7R1H104K050BB; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: TDK; Direct Alternate_mfr_part_number: C1005X7R1H104K050BE; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C15-C18 C96 C98 C331-C334 = CAP: CAP CERAMIC 2.2uF 10V 20% X5R 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM035R61A225ME01; Mistral Part No: 120022060026-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.57mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM035R61A225ME01.PDF
C63 C87 C95 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C68 C81 C84 C89 C92 C97 C375 C376 C380 C381 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C82 C85 C378 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C100 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C379 = CAP: CAP CERAMIC 1uF 25V 5% X7R 0805; Chkd/date: PRADEEP/150424; Crtd /date: SHANKARI/150424; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 478-KGM21AR71E105JUCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 08053C105JAT2A; Mistral Part No: 120024040007-R; Package: 0805; Part_type: CAPACITORS\CERAMIC; Project: AM62D_EVM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 25V; Wattage: NA; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_MLC.PDF
FL2 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 3A 0603; Chkd/date: MANIRAJA/251018; Crtd /date: ALVY/251018; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 490-13261-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.75MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM18KG121TH1D; Mistral Part No: 130018100051-R; Package: 0603; Part_type: INDUCTOR; Project: TI_J7ES_EVM_SOM; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 4mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM18XX-H1D-SER.PDF
J2 = CON_AUDIOJACK6_STX-4235-3_3: CON AUDIO JACK DUAL 6POS 3.50MM FEMALE RT TH; Chkd/date: MANIRAJA/090818; Crtd /date: ALVY/080818; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: MOUSER; Distributor_part_number: 806-STX-4235-3/3-N; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 26.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Library Ref: CON_AUDIOJACK6_STX-4235-3/3; Mfr_name: KYCON; Mfr_part_number: STX-4235-3/3-N; Mistral Part No: 150018080005-R; Package: THRU-HOLE; Part_type: CONNECTOR\JACK; Project: TI_J7ES_EVM_FUSION2_SER_CAP; RoHS: RoHS; Temperature: -25°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\STX-4235-3-3-N.PDF
J7 = HEADER_2X1: CON HDR 1X2 2.54MM PITCH ST TH; Chkd/date: NAVEED/210714; Crtd /date: USMAN/031012; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: WM8072-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 5.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: MOLEX; Mfr_part_number: 90120-0122; Mistral Part No: 150012100005-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: NPOL_FEP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 122mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\90120-XX.PDF
L3 = INDUCTOR: IND 2.2uH 20% 2.4A 0806; Chkd/date: PRADEEP/080124; Crtd /date: TAMILARASU/080124; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: F10231CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: LITTELFUSE INC; Mfr_part_number: LPWI201610H2R2T; Mistral Part No: 130024010015-R; Package: 0806; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: 0.2; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\LPWI201610H2R2T.PDF
R7-R10 R405-R408 = RESISTOR: RES 4.3K 1/16W 5% 0402; Chkd/date: VASANTHA/190614; Crtd /date: NAVEED/160614; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: RMCF0402JT4K30CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: STACKPOLE ELECTRONICS; Mfr_part_number: RMCF0402JT4K30; Mistral Part No: 110014060029-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS_POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.57mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RMCF-SER_JUL18.PDF
R67 = RESISTOR: RES 0E 1/10W 5% 0603; Chkd/date: MANIRAJA/051217; Crtd /date: BAVISH/180211; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0GRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: YAGEO AMERICA; Mfr_name: PANASONIC-ECG; Mfr_part_number: RC0603JR-070RL; Mistral Part No: 110011020013-R; Package: 0603; Part_type: RESISTORS\FIXED; Project: KENNEL; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R68 R78 R90 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP5 TP6 TP8 TP9 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U7 = PCM6240QRTVRQ1_WQFN32: IC AUTOMOTIVE 4-CHANNEL 768KHz AUDIO ADC WITH INTEGRATED MICROPHONE BIAS AND INPUT FAULT DIAGNOSTICS WQFN32; Chkd/date: PRADEEP/221123; Crtd /date: TAMILARASU/221123; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-PCM6240QRTVRQ1TR-ND; Height: 0.80MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140223110001-R; Package: WQFN32; Part_type: ICS\ATOD; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\ATOD_DTOA\PCM6240.PDF
U14 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Automotive Alternate_mfr_name: TEXAS INSTRUMENTS; Automotive Alternate_mfr_part_number: SN74LVC1G08QDBVRQ1; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF
C106 C113 C184 C185 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B1X7R1C104K050BC; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: MURATA; Direct Alternate_mfr_part_number: GCM155R71C104JA55D; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C107 C180 = CAP: CAP CERAMIC 4700pF 50V 10% X7R 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B2X7R1H472K050BA; Chkd/date: MANIRAJA/040419; Crtd /date: MANIRAJA/040419; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: SAMSUNG; Direct Alternate_mfr_part_number: CL05B472KB5NNNC; Distributor_name: DIGIKEY; Distributor_part_number: 490-1308-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R71H472KA01D; Mistral Part No: 120009030440-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM155R71H472KA01.PDF
J9 J15 = HEADER_3X1: CON HDR 1X3 2.54MM PITCH ST TH; Chkd/date: VASANTHA/211015; Crtd /date: VASANTHA/211015; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: 732-5316-ND; Height: 8.54MM; Mfr_name: WURTH ELECTRONICS INC; Mfr_part_number: 61300311121; Mistral Part No: 150015100037-R; Package: THRU-HOLE; Part_type: CONNECTOR\HEADERS; Project: CYPHY_ROADKILL; RoHS: RoHS; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\6130XXX.PDF
R81 R199 = RESISTOR: RES 33E 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: GEETHA/190406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P33JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ330X; Mistral Part No: 110009030699-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R82 R102 R213 R223 R273 R441 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R88 R93 R208 R215 = RESISTOR: RES 59E 1/10W 1% 0402; Chkd/date: MAZHAR/151208; Crtd /date: USMAN/031208; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P59.0LCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF59R0X; Mistral Part No: 110009031010-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: KHAN_HSST; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R96 R222 = RESISTOR: RES 100K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-100KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-07100KL; Mistral Part No: 110009030176-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U17 U38 = TCAN3413DR_SOIC8: IC 3.3V CAN FD TRANSCEIVERS WITH STANDBY MODE AND +/-58V BUS STANDOFF SOIC8; Crtd /date: TAMILARASU/221223; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_TELECOM_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 140123120005-R; Package: SOIC8; Part_type: ICS\TELECOM\TRANSCEIVER; Project: AM62D-EVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\TELECOM\TCAN3413.PDF
C122 C126 = CAP: CAP CERAMIC 0.01uF 25V 10% X5R AUTO 0201; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT033R61E103KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033R61E103KE01D; Mistral Part No: 120021120019-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 10%; Voltage: 25V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033R61E103KE01.PDF
LD1 LD10 = DIODE_LED: DIODE LED BRIGHT GREEN SMD; Chkd/date: MANIRAJA/180820; Crtd /date: ALVY/180820; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 732-4986-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_OPTO_Library.schlib; Mfr_name: WURTH ELECTRONICS; Mistral Part No: 130020080012-R; Package: SMD; Part_type: OPTO\LED; Project: AM64x_EVM_BRD; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 10mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\LEDS\150080VS75000.PDF
Q1 Q5 = MOSFET_CSD17313Q2: IC MOSFET N-CHANNEL NEXFET 25V WSON6; Chkd/date: ALVY/071220; Crtd /date: MANIRAJA/071220; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-25260-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.80MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MOSFET_Library.schlib; Manufacturer: TEXAS INSTRUMENTS; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 142020120008-R; Package: WSON6; Part_type: ICS\POWER\MOSFET; Project: TI_AM243x LP EVM; RoHS: RoHS; Temperature: -55°C+150°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 8.7mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\POWER\CSD16301Q2.PDF
R180 R440 = RESISTOR: RES 220E 1/10W 5% 0402; Chkd/date: VASANTHA/291216; Crtd /date: GEETHA/260406; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P220JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ221X; Mistral Part No: 110009030506-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: RED EYE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R436 = RESISTOR: RES 10K 1/16W 5% 0402; Assembly_Instruction: DNI; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
U18 = TCA6416ARTWR_WQFN24: IC I2C I/O EXPANDER 16Bit WQFN24; Chkd/date: VASANTHA/011016; Crtd /date: VASANTHA/011016; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-24826-1-ND; Height: 0.80MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141016100001-R; Package: WQFN24; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: OCTBTS5200_FEM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\TCA6416.PDF
U21 = TCA6424ARGJR_QFN32: IC I2C I/O EXPANDER 24B UQFN32; Chkd/date: NAVEED/100715; Crtd /date: NAVEED/100914; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-27844-1-ND; Height: 0.60MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141014090009-R; Package: UQFN32; Part_type: ICS\DIGITAL\BUSTRANSCEIVER; Project: ZK_BIOMETRIC; RoHS: RoHS; Temperature: -40°C+85°C; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\BUSTRANSCEIVER\TCA6424AR.PDF
U78 = TXB0304RUTR_QFN12: IC VOLTAGE-LEVEL TRANSLATOR 4-BIT BIDIRECTIONAL UQFN12; Chkd/date: NAVEED/130415; Crtd /date: JEBRAN/090415; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-29682-1-ND; Height: 0.55MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141015040005-R; Package: UQFN12; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Project: GALILEO; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TXB0304RUTR.PDF
U79 = TXB0102DCUR_US8: IC 2-BIT BI-DIR VOLTAGE-LEVEL TRANSLATOR WITH AUTO DIRECTION SENSING AND ESD PROTECTION VSSOP8; Chkd/date: VASANTHA/221216; Crtd /date: USMAN/290609; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-22862-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCINTERFACE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060040-R; Package: VSSOP8; Part_type: ICS\INTERFACE\LEVEL TRANSLATOR; Project: BUG_BASE-II; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 9.6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\INTERFACE\TXB0102-SER.PDF

## Nets
DGND: C3.2 C15.1 C17.1 C63.2 C68.2 C81.2 C82.2 C84.2 C85.2 C87.2 C89.2 C92.1 C95.2 C96.2 C97.1 C98.2 C100.2 C106.1 C107.2 C109.2 C113.2 C122.1 C126.1 C180.2 C184.1 C185.1 C220.1 C329.2 C332.1 C334.1 C375.2 C376.2 C378.2 C379.2 C380.2 C381.2 C425.1 C478.1 C489.1 C609.1 C622.1 D10.1 D11.1 D12.1 D14.1 J2.1A J2.1B J7.2 J9.2 J15.2 Q1.4(S1) Q1.7(S2) Q5.4(S1) Q5.7(S2) Q6.3(D) Q7.3(D) R22.2 R26.2 R68.1 R94.2 R107.2 R203.1 R250.1 R274.1 R427.1 R428.2 R442.1 SW4.1 SW4.4 SW5.1 SW5.4 SW6.1 SW6.4 SW8.1 SW8.4 U7.8(AVSS) U7.33(VSS) U14.3(GND) U17.2(GND) U18.9(GND) U18.25(PAD) U21.25(GND) U21.33(EP) U38.2(GND) U50.4(GND) U78.6(GND) U79.2(GND) U98.4(GND) ; also on sheet 1 2 3 4 5 6 7 8 9 10 12 13 14 16 17 18 19 20 21 22 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54
VBAT_IN: C95.1 C100.1 J7.1 U7.21(VBAT_IN) ; also on sheet 5
VCC1V8_SYS: C106.2 C220.2 C376.1 C381.1 R67.2 R96.1 R268.1 R279.2 R375.1 R434.2 R436.1 R532.1 U17.5(SHDN/VIO) U50.8(VCC) U78.1(VCCA) U79.3(VCCA) ; also on sheet 1 2 4 6 7 10 20 21 22 33 37 38 39 43 49 50 52 53 54
VCC_1V8_IOVDD: C84.1 C85.1 C109.1 R20.1 R23.1 R67.1 R78.2 R90.2 U7.27(IOVDD) U14.5(VCC) ; also on sheet 5 16
VCC_3V3_AVDD: C63.1 C68.1 C97.2 C98.1 FL2.2 L3.1 U7.1(AVDD) U7.3(BSTVDD) ; also on sheet 5
VCC_3V3_SYS: C113.1 C122.2 C126.2 C184.2 C185.2 C375.1 C380.1 C478.2 FL2.1 R98.2 R106.2 R180.2 R222.1 R440.2 R550.1 R559.1 R615.1 U17.3(VCC) U18.21(VCCP) U18.23(VCCI) U21.27(VCCP) U21.31(VCC) U38.3(VCC) U38.5(SHDN/VIO) U78.11(VCCB) U79.7(VCCB) U98.8(VCC) ; also on sheet 1 2 3 6 10 14 17 18 19 20 22 31 33 37 38 40 41 42 45 46 48 49 50 51 52 53 54
ADDR0_IO_EXP: R107.1 U21.26(ADDR)
ADDR1_IO_EXP: R94.1 U18.18(ADDR)
CPLD1_DONE: U21.12(P13) ; also on sheet 22
CPLD1_INTN: U21.13(P14) ; also on sheet 22
CPLD1_JTAGENB: U18.3(P02) ; also on sheet 22
CPLD1_PROGRAMN: U18.4(P03) ; also on sheet 22
CPLD2_DONE: U21.10(P11) ; also on sheet 20
CPLD2_INTN: U21.11(P12) ; also on sheet 20
CPLD2_JTAGENB: U18.5(P04) ; also on sheet 20
CPLD2_PROGRAMN: U18.6(P05) ; also on sheet 20
DAC_LAT_CTRL: U18.2(P01) ; also on sheet 50
DEBOUNCE_GPIO_INT_MCU_SoC: C489.2 D11.2 Q7.2(S) R559.2 SW5.2 SW5.3 U98.3(2A)
DEBOUNCE_MCU_RESETz: C609.2 D12.2 R615.2 SW6.2 SW6.3 U98.1(1A)
DEBOUNCE_SOC_PORz: C622.2 D14.2 R375.2 SW8.2 SW8.3 U50.1(1A)
DEBOUNCE_SOC_WARMRESETn: C425.2 D10.2 Q6.2(S) R532.2 SW4.2 SW4.3 U50.3(2A)
DIX_INT: U21.8(P07) U78.8(B3)
DIX_INT_1V8: U78.4(A3) ; also on sheet 49
GPIO1_23_INTn: R108.1 R547.2 U79.1(B2)
GPIO1_23_INTn_1V8: U79.4(A2) ; also on sheet 7
GPIO_CPSW1_RST: U21.2(P01) ; also on sheet 40
GPIO_CPSW2_RST: U21.1(P00) ; also on sheet 41
GPIO_DIX_RST: U21.6(P05) ; also on sheet 49
GPIO_eMMC_RSTn: U21.9(P10) ; also on sheet 37
GPIO_MCU_SoC: R546.1 R547.1 U98.5(2Y)
GPIO_MCU_SoC_INTn: R546.2 ; also on sheet 48
GPIO_PCM1_RST: R84.1 U21.17(P20)
GPIO_PCM2_RST: U21.19(P22) ; also on sheet 5
IO_EXP0_INTn: R106.1 R108.2 U21.32(~{INT})
IO_EXP1_INTn: R98.1 U18.22(~{INT})
IO_EXP_OPT_EN: U21.7(P06) ; also on sheet 49
IO_EXP_TEST_LED: R441.1 U21.24(P27)
IO_MCAN0_STB: R102.2 U21.21(P24)
IO_MCAN1_STB: R223.2 U21.22(P25)
MCAN0_CAN_H: J9.1 R93.1 U17.7(CANH)
MCAN0_CAN_L: J9.3 R88.2 U17.6(CANL)
MCAN0_RX: R81.1 ; also on sheet 7
MCAN0_RX_R: R81.2 U17.4(RXD)
MCAN0_STB: R96.2 R102.1 U17.8(STB)
MCAN0_T: C107.1 R88.1 R93.2
MCAN0_TX: R82.2 ; also on sheet 7
MCAN0_TX_R: R82.1 U17.1(TXD)
MCAN1_CAN_H: J15.1 R215.1 U38.7(CANH)
MCAN1_CAN_L: J15.3 R208.2 U38.6(CANL)
MCAN1_RX_R: R199.2 U38.4(RXD)
MCAN1_STB: R222.2 R223.1 U38.8(STB)
MCAN1_T: C180.1 R208.1 R215.2
MCAN1_TX_R: R273.1 U38.1(TXD)
MCU_MCAN0_RX: R199.1 ; also on sheet 48
MCU_MCAN0_TX: R273.2 ; also on sheet 48
MCU_RESETz: R550.2 TP50.1(TP) U98.7(1Y) ; also on sheet 10
MIC1_BIAS: C3.1 C329.1 C379.1 R7.1 R8.1 R9.1 R10.1 R405.1 R406.1 R407.1 R408.1 U7.6(MICBIAS)
MMC1_SD_EN: U21.4(P03) ; also on sheet 38
PCM1_ADDR_0: R20.2 R26.1 U7.24(ADDR0_SCLK)
PCM1_ADDR_1: R22.1 R23.2 U7.23(ADDR1_MISO)
PCM1_AREG: C89.1 C378.1 U7.2(AREG)
PCM1_BSTOUT: C92.2 C96.1 U7.5(BSTOUT)
PCM1_DREG: C81.1 C82.1 U7.32(DREG)
PCM1_GPIO1: R34.2 U7.28(GPIO1) ; also on sheet 5
PCM1_IN1N: C17.2 R9.2 U7.10(IN1M)
PCM1_IN1P: C18.2 R10.2 U7.9(IN1P)
PCM1_IN2N: C15.2 R7.2 U7.12(IN2M)
PCM1_IN2P: C16.2 R8.2 U7.11(IN2P)
PCM1_IN3N: C334.2 R408.2 U7.14(IN3M)
PCM1_IN3P: C333.2 R407.2 U7.13(IN3P)
PCM1_IN4N: C332.2 R406.2 U7.16(IN4M)
PCM1_IN4P: C331.2 R405.2 U7.15(IN4P)
PCM1_INT: U21.15(P16) U78.10(B1)
PCM1_INT_1V8: R34.1 U78.2(A1)
PCM1_McASP2_AXR14: R38.2 U7.29(SDOUT)
PCM1_RESETn: R68.2 R78.1 U7.22(SHDNZ) U14.4(Y)
PCM1_VREF: C87.1 U7.7(VREF)
PCM2_INT: U21.16(P17) U78.9(B2)
PCM2_INT_1V8: U78.3(A2) ; also on sheet 5
PCM6240_McASP2_ACLKR: U7.30(BCLK) ; also on sheet 5 16
PCM6240_McASP2_AFSR: U7.31(FSYNC) ; also on sheet 5 20
PCM6240_McASP2_AXR14: R38.1 ; also on sheet 5 16
PD_I2C_IRQ: U21.23(P26) ; also on sheet 31
RESETSTATz: U14.2(B) U18.24(~{RESET}) U21.28(~{RESET}) ; also on sheet 5 10 37 38 39 40 41 43 49
SOC_GPIO1_49: R213.1 ; also on sheet 37
SoC_I2C0_SCL: U18.19(SCL) U21.29(SCL) ; also on sheet 1 3 17 20 22 40 41 50
SoC_I2C0_SCL_1V8: U7.25(SCL_MOSI) ; also on sheet 1 5 7 21 49 50 53
SoC_I2C0_SDA: U18.20(SDA) U21.30(SDA) ; also on sheet 1 3 17 20 22 40 41 50
SoC_I2C0_SDA_1V8: U7.26(SDA_SSZ) ; also on sheet 1 5 7 21 49 50 53
SOC_PORz_PB: R268.2 TP55.1(TP) U50.7(1Y) ; also on sheet 10
SoC_WARM_RESETZ: R279.1 TP57.1(TP) U50.5(2Y) ; also on sheet 10
TEST_GPIO1: Q7.1(G) ; also on sheet 3
TEST_GPIO2: U21.18(P21) ; also on sheet 3
TEST_WARMRESETn: Q6.1(G) ; also on sheet 3
USB_TYPEA_OC_INDICATION: U21.14(P15) ; also on sheet 51
VPP_EN: U21.5(P04) ; also on sheet 14
VSEL_SD_SOC: U79.8(B1) ; also on sheet 14
VSEL_SD_SOC_1V8: U79.5(A1) ; also on sheet 7
N24591228: R274.2 U50.6(3A)
N24605604: C18.1 J2.5A
N24605606: C16.1 J2.2A
N24605709: R84.2 R90.1 U14.1(A)
N24605835: TP5.1(TP) U7.20(GPIO2)
N24605846: L3.2 U7.4(BSTSW)
N24605909: C333.1 J2.5B
N24606047: TP8.1(TP) U7.19(GPI1)
N24606049: TP9.1(TP) U7.17(GPI2)
N24606166: C331.1 J2.2B
N25521527: TP6.1(TP) U7.18(GPIO3)
N25906633: R250.2 U98.6(3A)
N27173972: Q1.3(G) R203.2 R213.2
N27173989: Q5.3(G) R441.2 R442.2
N27174010: LD10.1(CATHODE) Q5.1(D1) Q5.2(D2) Q5.5(D3) Q5.6(D4) Q5.8(D5)
N27174034: LD1.1(CATHODE) Q1.1(D1) Q1.2(D2) Q1.5(D3) Q1.6(D4) Q1.8(D5)
N27174097: LD1.2(ANODE) R180.1
N27174144: LD10.2(ANODE) R440.1
N27380200: R427.2 U78.5(A4)
N27380212: R428.1 U78.7(B4)
N27380351: R434.1 U78.12(OE)
N27381124: R436.2 U79.6(OE)

Not connected (* = marked no-connect by the designer): U18 1(P00)* 7(P06)* 8(P07)* 10(P10)* 11(P11)* 12(P12)* 13(P13)* 14(P14)* 15(P15)* 16(P16)* 17(P17)*; U21 3(P02)* 20(P23)*; U50 2(3Y)*; U98 2(3Y)*

## Notes on the sheets
sheet 55
- IO EXPANDER
- Note : MMC1_SD_EN, VPP_EN
  Connect to an SOC GPIO when IO expander is not used
- I2C ADDRESS: 0x22
- I2C ADDRESS: 0x20
- LEVEL TRANSLATOR
- USER TEST LEDS
- SoC GPIO
- IO EXP GPIO
sheet 56
- AUDIO - MICROPHONE/LINE IN 1
- I2C ADDRESS: 0X90
- PCM1 RESET
- ADC Supply & Decaps
- CAD Note: Place these decaps near the IOVDD supply pin
- I2C address selection
          device 1
- CAD Note: Place these decaps near the AVDD supply pin
sheet 57
- SOC RESET - 2
- MCU WARM RESET
- SOC PORZ
- RESET & INT DEBOUNCE CIRCUIT
- Silk: MCU WARM RST
- Silk: PORz
- SOC WARM RESET
- LVCMOS inputs have slew rate requirement.
  Schmitt trigger is for the slow ramp pushbutton RC
  connected to the SoC warm reset inputs
  This is recommended when push button or RC is used.
- Silk: RST
- LVCMOS inputs have slew rate requirement.
  Schmitt trigger is for the slow ramp pushbutton RC
  connected to the SoC warm reset inputs
  This is recommended when push button or RC is used.
- USER INTERRUPT
- Silk: INT
sheet 58
- CAN TRANSCEIVER
- 120E
- 120E
