# OrCAD Capture schematic PROC180E1_SCH.DSN, sheet 59 of 59

## Sheets
59 59. MOUNTING HARDWARE: title: MOUNTING HARDWARE

## Parts
ACC1  GT-BGA-2001  [BGASKT484_GT-BGA-2001_910X910_10-7]
ACC2  SPC02SYAN  [NA]
ACC3  SPC02SYAN  [NA]
FID1  FID_40X80  [FID_40X80]
FID2  FID_40X80  [FID_40X80]
FID3  FID_40X80  [FID_40X80]
FID4  FID_40X80  [FID_40X80]
FID5  FID_40X80  [FID_40X80]
FID6  FID_40X80  [FID_40X80]
LBL1  THT-103-423-10  [NA]
LBL2  THT-103-423-10  [NA]
LBL3  AM6-COMPROCEVM  [NA]
LOGO1  Texas Intruments  [TI_Stacked_Overlay_Small]
LOGO2  For Evaluation only; not FCC approved for resale  [FCC_disclaimer]
LOGO3  WEEE Mark  [TI_Stacked_Overlay_Small]
LOGO4  CE Mark  [TI_Stacked_Overlay_Small]
PCB1  PROC180

## Library data of the parts
ACC1 = ACCESSORY: ACCESSORIE BGA SOCKET AM62A SVB SoC MICROPROCESSOR FCBGA484; Chkd/date: ALVY/180422; Crtd /date: ALVY/180422; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: NA; Height: 10.69MM; Library Path: NA; Mfr_name: IRONWOOD ELECTRONICS; Mistral Part No: 160022040013; Package: FCBGA484; Part_type: ACCESSORIES; Project: TI_AM62A_SVB_BRD; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\ACCESSORIES\GT-BGA-2001.PDF
ACC2 ACC3 = ACCESSORY: ACCESSORIE JUMPER SHORTING GOLD FLASH; Chkd/date: SUHAS\211010; Crtd /date: USMAN/301208; Distributor_name: DIGIKEY; Distributor_part_number: S9001-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: SULLINS CONNECTOR; Mistral Part No: 160009030153-R; Part_type: ACCESSORIES; Project: SMART VIEW_NVR; RoHS: RoHS; Temperature: -55°C+105°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\MODULES\SPC02SYAN.PDF
FID1-FID6 = Fiducial
LBL1 LBL2 = ACCESSORY_THT-3-423-10: ACCESSORIE 1 WORKHORSE POLYSTER LABLE 0.25" X 1"; Chkd/date: MANIRAJA/270218; Crtd /date: ALVY/260218; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: BRADY; Mistral Part No: 160018020185; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB
LBL3 = ACCESSORY_THT-3-423-10: ACCESSORIE 1 WORKHORSE POLYSTER LABLE 0.25" X 1"; Chkd/date: MANIRAJA/270218; Crtd /date: ALVY/260218; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MECHANICAL_Library.schlib; Mfr_name: BRADY; Mfr_part_number: THT-103-423-10; Mistral Part No: 160018020185; Part_type: ACCESSORIES; Project: TI_MAXIE_CPB
LOGO1 LOGO3 LOGO4 = TI_Logo
LOGO2 = FCC_disclaimer
PCB1 = PCB_0: AM62D EVM; Mfr_part_number: PROC180E1; Mistral Part No: FY22-23/00176000401

## Nets

## Notes on the sheets
sheet 59
- MOUNTING HARDWARE
- LOGOs
- ASSEMBLY NOTES
- BARE PCB
- 1. All MSL components should be baked as per JEDEC standard.
  2. PCB should be baked at 120 degree for 8 hours.
  3. Board assembly must comply with workmanship standards.
  IPC-A-610 Class 2, unless otherwise specified.
  4. These assemblies are ESD sensitive, ESD precautions
  shall be observed.
  5. These assemblies must be clean and free from flux and
  all contaminants. Use of no clean flux is not acceptable.
  6. Provide serial numbers to the assembled boards for identification.
  7. The assembled board are wrapped in ESD Covers(individual) and
  packed securely before shipment.
- Texas Intruments
- For Evaluation only; not FCC approved for resale
- WEEE Mark
- CE Mark
- JUMPERS
- AM62A SOCKET
- FIDUCIALS
- LABELS
- EVM Orderable No.
- Board Serial No.
- Orderable Part Numbers
- Assembly Revision
- Variant
- Label Text
- 001
- AUDIO-AM62D-EVM
