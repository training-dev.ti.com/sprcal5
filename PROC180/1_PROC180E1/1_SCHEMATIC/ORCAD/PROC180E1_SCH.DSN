# OrCAD Capture schematic PROC180E1_SCH.DSN, sheets 39 to 41 of 59

## Sheets
39 25. OSPI INTERFACE: size C; title: OSPI INTERFACE
40 31. CPSW3G RGMII_1: size C; title: ETHERNET EXPANSION CONNECTOR CPSW3G RGMII 1
41 32. CPSW3G RGMII_2: size C; title: ETHERNET EXPANSION CONNECTOR CPSW3G RGMII 2

## Parts
sheet 25. OSPI INTERFACE
C148  0.1uF  [CAP0402_0-75]
C149  4.7uF  [CAP0402_0-75]
C388  0.1uF  [CAP0402_0-75]
C389  0.1uF  [CAP0402_0-75]
C390  0.1uF  [CAP0402_0-75]
R121  0E  [RES0201_0-5]
R122  10K  [RES0201_0-5]
R123  10K  [RES0201_0-5]
R124  10K  [RES0201_0-5]
R125  0E  [RES0201_0-5]
R197  0E  [RES0402_0-5]
R206  0E  [RES0201_0-5]
R443  10K  [RES0201_0-5]
R444  10K  [RES0201_0-5]
R445  10K  [RES0201_0-5]
R446  10K  [RES0201_0-5]
R447  10K  [RES0201_0-5]
R448  10K  [RES0201_0-5]
R449  10K  [RES0201_0-5]
R450  10K  [RES0201_0-5]
R451  10K  [RES0201_0-5]
R452  10K  [RES0201_0-5]
R453  22E  [RES0201_0-5]
R454  10K  [RES0201_0-5]
R504  1K  [RES0201_0-5]
RA3  0E  [RESA_EXB_0201-4_0-5]
RA4  0E  [RESA_EXB_0201-4_0-5]
U27  SN74LVC1G08DBVRE4  [SOT23-5]
U28  S28HS512TGABHM010  [BGA24_39-37_240X310_1]
sheet 30. SOC PERIPHERALS 3
U47  XAM62D24AVGHIANF  [FBGA484_31-49_710X710_2-7]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N,O,P,Q)
sheet 31. CPSW3G RGMII_1
C272  10uF  [CAP0402_0-75]
C274  10uF  [CAP0402_0-75]
C278  0.1uF  [CAP0402_0-75]
C279  0.1uF  [CAP0402_0-75]
C293  0.1uF  [CAP0201_0-5]
C610  1000pF  [CAP1206_1-75]
J18  CON_BTOB_2X24_M  [CON_BTOB2X24_DF40GB-48DP_P_S_S_1-3]
R338  0E  [RES0402_0-5]
R340  0E  [RES0402_0-5]
R342  10K  [RES0201_0-5]
R343  1.5K  [RES0201_0-5]
R353  100K  [RES0201_0-5]
R355  1K_1%  [RES0402_0-5]
R360  100K  [RES0201_0-5]
R362  10K  [RES0201_0-5]
R363  10K  [RES0201_0-5]
R364  0E  [RES0201_0-5]
R366  0E  [RES0201_0-5]
R367  10K  [RES0201_0-5]
R373  10K  [RES0201_0-5]
R620  2.2K  [RES0201_0-5]
R621  0E  [RES0201_0-5]
R623  0E  [RES0201_0-5]
R638  10K  [RES0402_0-5]
R639  1K  [RES0402_0-5]
R641  10K  [RES0402_0-5]
R642  1K  [RES0402_0-5]
TP65  TP30_SMD  [TP30_SMD]
TP93  TP30_SMD  [TP30_SMD]
TP95  TP30_SMD  [TP30_SMD]
TP98  TP30_SMD  [TP30_SMD]
TP99  TP30_SMD  [TP30_SMD]
U68  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]
sheet 32. CPSW3G RGMII_2
C271  10uF  [CAP0402_0-75]
C273  10uF  [CAP0402_0-75]
C276  0.1uF  [CAP0402_0-75]
C277  0.1uF  [CAP0402_0-75]
C602  0.1uF  [CAP0201_0-5]
C611  1000pF  [CAP1206_1-75]
J19  CON_BTOB_2X24_M  [CON_BTOB2X24_DF40GB-48DP_P_S_S_1-3]
R341  1K_1%  [RES0402_0-5]
R344  2.2K  [RES0201_0-5]
R345  0E  [RES0201_0-5]
R346  0E  [RES0201_0-5]
R347  100K  [RES0201_0-5]
R351  1.5K  [RES0201_0-5]
R352  0E  [RES0201_0-5]
R354  100K  [RES0201_0-5]
R356  10K  [RES0201_0-5]
R601  10K  [RES0201_0-5]
R602  10K  [RES0201_0-5]
R604  0E  [RES0201_0-5]
R605  0E  [RES0201_0-5]
R606  10K  [RES0201_0-5]
R607  10K  [RES0201_0-5]
R616  10K  [RES0402_0-5]
R618  1K  [RES0402_0-5]
R622  10K  [RES0402_0-5]
R624  0E  [RES0201_0-5]
R625  1K  [RES0402_0-5]
R626  10K  [RES0402_0-5]
R628  1K  [RES0402_0-5]
R629  1K  [RES0402_0-5]
R630  10K  [RES0402_0-5]
TP59  TP30_SMD  [TP30_SMD]
TP87  TP30_SMD  [TP30_SMD]
TP89  TP30_SMD  [TP30_SMD]
TP91  TP30_SMD  [TP30_SMD]
TP94  TP30_SMD  [TP30_SMD]
U120  SN74LVC1G11DRYR  [SON6_SN74LVC2G17_40X60_0-6]

## Library data of the parts
C148 C388-C390 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C149 = CAP: CAP CERAMIC 4.7uF 10V 20% X5R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R61A475ME13; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.65MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R61A475ME13D; Mistral Part No: 120021020032-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 1.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R61A475ME13.PDF
R121 R125 R345 R346 R352 R364 R366 R604 R605 R621 R623 R624 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R122-R124 R342 R356 R362 R363 R367 R373 R443-R452 R454 R601 R602 R606 R607 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R197 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0402_0-5_0E_0E; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R206 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R453 = RESISTOR: RES 22E 1/20W 5% 0201; Chkd/date: ALVY/210122; Crtd /date: TAMILARASU/210122; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-22AGCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.28MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW020122R0JNED; Mistral Part No: 110022010021-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: DLRL DIGITAL RECEIVER_BRD; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_22E_1%_22E_1%; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0201.PDF
R504 = RESISTOR: RES 1K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071KL; Mistral Part No: 110009030395-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
RA3 RA4 = RESARR_ISO4: RES ARRAY 0E 31mW JUMPER 0201-4; Chkd/date: MANIRAJA/290918; Crtd /date: MANIRAJA/290918; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: Y6000CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.45MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: PANASONIC-ECG; Mfr_name: PANASONIC-ECG; Mfr_part_number: EXB-18VR000X; Mistral Part No: 110018090033-R; Package: 0201-4; Part_type: RESISTORS\ARRAY; Project: TI_60GHz-AOP; RoHS: RoHS; SIGNAL_MODEL: RESARR_ISO4_RESA_EXB_0201-4_0-5_0E; Temperature: -55°C+125°C; Tolerance: NA; Voltage: NA; Wattage: 31mW; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\EXB-18V.PDF
U27 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF
U28 = S28HS512T_BGA24: IC 1.8V 512Mb SEMPER FLASH WITH OCTAL INTERFACE BGA24; Chkd/date: MANIRAJA/170120; Crtd /date: ALVY/170120; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_MISCMEMORY_Library.schlib; Mfr_name: CYPRESS SEMICONDUCTOR; Mistral Part No: 141120010002; Package: BGA24; Part_type: ICS\DIGITAL\MEMORY; Project: J7VCL_SOM DUAL LEO PMIC; RoHS: NA; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\MEMORY\S28HS512T.PDF
U47 = AM62D_EVM_SOC_FCBGA484: IC AM62D EVM SoC MICROPROCESSOR FCBGA484; Chkd/date: PRADEEP/010424; Crtd /date: PRADEEP/010424; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.65MM; Library Ref: AM62D_EVM_SoC_FCBGA484; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141224040001-R; Package: FCBGA484; Part_type: ICS\DIGITAL\MICROPROCESSOR; Project: AM62D_EVM; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\MICROCONTROLLER\AM62A_SK_EVM.PDF
C271-C274 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C276-C279 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R 0402; Chkd/date: MANIRAJA/261020; Crtd /date: ALVY/211020; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-10700-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R71H104KE14D; Mistral Part No: 120011100014-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: J7_CP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 50V; Wattage: NA; Weight: 3.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM155R71H104KE14.PDF
C293 C602 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C610 C611 = CAP: CAP CERAMIC 1000pF 2KV 10% X7R 1206; Chkd/date: SHREESHAIL/291106; Crtd /date: MAZHAR/281106; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 478-2956-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.52MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: 1206GC102KAT1A; Mistral Part No: 120015080006-R; Package: 1206; Part_type: CAPACITORS\CERAMIC; Project: ADR1B; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 2KV; Wattage: NA; Weight: 16.2mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX_HV-MLC.PDF
J18 J19 = CON_BTOB_24X2_M_SH4: CON BTOB 2X24 0.40MM PITCH MALE ST SMD; Chkd/date: PRAVEEN/290323; Crtd /date: PRAVEEN/290323; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: H124956CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.30MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: HIROSE ELECTRIC EUROPE; Mfr_part_number: DF40GB-48DP-0.4V(58); Mistral Part No: 150023030029-R; Package: SMD; Part_type: CONNECTOR\BTOB; Project: AM263P_CC; RoHS: RoHS; Temperature: -35°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\DF40GB-48DP-0.4V.PDF
R338 R340 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R343 = RESISTOR: RES 1.5K 1/20W 5% 0201; Chkd/date: ALVY/070422; Crtd /date: TAMILARASU/070422; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1.5KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-071K5L; Mistral Part No: 110010070057-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R347 R353 R354 R360 = RESISTOR: RES 100K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-100KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-07100KL; Mistral Part No: 110009030176-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R341 R355 = RESISTOR: RES 1K 1/10W 1% 0402; Chkd/date: VASANTHA/281216; Crtd /date: MAZHAR/150506; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.00KLCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF1001X; Mistral Part No: 110009030411-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: VOCERA; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R344 R620 = RESISTOR: RES 2.2K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-2.2KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-072K2L; Mistral Part No: 110009030427-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R616 R622 R626 R630 R638 R641 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R618 R625 R628 R629 R639 R642 = RESISTOR: RES 1K 1/10W 5% 0402; Chkd/date: VASANTHA/201216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.0KJCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GEJ102X; Mistral Part No: 110009030400-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
TP59 TP65 TP87 TP89 TP91 TP93-TP95 TP98 TP99 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U68 U120 = SN74LVC1G11DCKR_SC70-6: IC SINGLE 3-INPUT POSITIVE-AND GATE SON6; Chkd/date: MANIRAJA/270121; Crtd /date: ALVY/270121; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-30120-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_GATE_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141021010013-R; Package: SON6; Part_type: ICS\DIGITAL\GATES; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G_NOV16.PDF
R351 = RESISTOR: RES 1.5K 1/20W 5% 0201; Chkd/date: MAZHAR/130208; Crtd /date: USMAN/130208; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P1.5KAGCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Manufacturer: PANASONIC-ECG; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-1GEJ152C; Mistral Part No: 110010070057-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: SMART VIEW_IP CAMERA; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.15mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJXGE-FEB06.PDF

## Nets
DGND: C148.2 C149.1 C271.2 C272.2 C273.2 C274.2 C276.2 C277.2 C278.2 C279.2 C293.2 C388.2 C389.2 C390.2 C602.2 C610.2 C611.2 J18.1 J18.5 J18.8 J18.15 J18.16 J18.17 J18.18 J18.21 J18.24 J18.31 J18.32 J18.33 J18.34 J18.41 J19.1 J19.5 J19.8 J19.15 J19.16 J19.17 J19.18 J19.21 J19.24 J19.31 J19.32 J19.33 J19.34 J19.41 R341.1 R355.1 R367.2 R373.2 R451.2 R504.2 R606.2 R607.2 R618.1 R622.1 R623.1 R624.1 R626.1 R628.1 R639.1 R642.1 U27.3(GND) U28.B3(VSS) U28.C1(VSSQ) U28.E5(VSSQ) U68.2(GND) U120.2(GND) ; also on sheet 1 2 3 4 5 6 7 8 9 10 12 13 14 16 17 18 19 20 21 22 31 32 33 34 35 36 37 38 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58
VCC1V8_SYS: C148.1 C149.2 C388.1 C389.1 C390.1 R122.2 R123.2 R124.2 R443.2 R444.2 R445.2 R446.2 R447.2 R448.2 R449.2 R450.2 R452.2 R454.2 U27.5(VCC) U28.B4(VCC) U28.D1(VCCQ) U28.E4(VCCQ) ; also on sheet 1 2 4 6 7 10 20 21 22 33 37 38 43 49 50 52 53 54 55 56 57 58
VCC_3V3_SYS: C271.1 C274.1 C277.1 C279.1 C293.1 C602.1 J18.44 J18.46 J19.44 J19.46 R342.1 R343.2 R344.1 R347.1 R351.2 R353.1 R354.1 R356.1 R360.1 R362.2 R363.2 R601.2 R602.2 R616.2 R620.2 R625.2 R629.2 R630.2 R638.2 R641.2 U68.5(VCC) U120.5(VCC) ; also on sheet 1 2 3 6 10 14 17 18 19 20 22 31 33 37 38 42 45 46 48 49 50 51 52 53 54 55 56 57 58
VDD_2V5: C272.1 C273.1 C276.1 C278.1 J18.4 J18.6 J19.4 J19.6 ; also on sheet 42
1588_SFD_1: J18.38 TP93.1(TP)
1588_SFD_2: J19.38 TP87.1(TP)
CPLD_CPSW_RGMII1_BCLK: J18.48 ; also on sheet 22
CPLD_CPSW_RGMII1_COL: J18.14 ; also on sheet 20
CPLD_CPSW_RGMII1_CRS: J18.30 ; also on sheet 20
CPLD_CPSW_RGMII2_BCLK: J19.48 ; also on sheet 22
CPLD_CPSW_RGMII2_COL: J19.14 ; also on sheet 20
CPLD_CPSW_RGMII2_CRS: J19.30 ; also on sheet 20
CPSW_ETH_INTn: R621.1 ; also on sheet 10
CPSW_RGMII1_BRD_CONN_DET: J18.36 R355.2
CPSW_RGMII1_ETH1_CLK: J18.28 ; also on sheet 48
CPSW_RGMII1_MDC: J18.20 R338.2 R342.2
CPSW_RGMII1_MDIO: J18.22 R340.2 R343.1
CPSW_RGMII1_RD0: J18.23 ; also on sheet 11
CPSW_RGMII1_RD1: J18.25 ; also on sheet 11
CPSW_RGMII1_RD2: J18.27 ; also on sheet 11
CPSW_RGMII1_RD3: J18.29 ; also on sheet 11
CPSW_RGMII1_RESETn: J18.12 R373.1 U68.4(Y)
CPSW_RGMII1_RX_DV: J18.45 ; also on sheet 11
CPSW_RGMII1_RXC: J18.19 ; also on sheet 11
CPSW_RGMII1_TD0: J18.7 ; also on sheet 11
CPSW_RGMII1_TD1: J18.9 ; also on sheet 11
CPSW_RGMII1_TD2: J18.11 ; also on sheet 11
CPSW_RGMII1_TD3: J18.13 ; also on sheet 11
CPSW_RGMII1_TX_EN: J18.35 ; also on sheet 11
CPSW_RGMII1_TXC: J18.3 ; also on sheet 11
CPSW_RGMII2_BRD_CONN_DET: J19.36 R341.2
CPSW_RGMII2_ETH2_CLK: J19.28 ; also on sheet 48
CPSW_RGMII2_MDC: J19.20 R352.2 R356.2
CPSW_RGMII2_MDIO: J19.22 R345.2 R351.1
CPSW_RGMII2_RD0: J19.23 ; also on sheet 11
CPSW_RGMII2_RD1: J19.25 ; also on sheet 11
CPSW_RGMII2_RD2: J19.27 ; also on sheet 11
CPSW_RGMII2_RD3: J19.29 ; also on sheet 11
CPSW_RGMII2_RSTn: J19.12 R607.1 U120.4(Y)
CPSW_RGMII2_RX_DV: J19.45 ; also on sheet 11
CPSW_RGMII2_RXC: J19.19 ; also on sheet 11
CPSW_RGMII2_TD0: J19.7 ; also on sheet 11
CPSW_RGMII2_TD1: J19.9 ; also on sheet 11
CPSW_RGMII2_TD2: J19.11 ; also on sheet 11
CPSW_RGMII2_TD3: J19.13 ; also on sheet 11
CPSW_RGMII2_TX_EN: J19.35 ; also on sheet 11
CPSW_RGMII2_TXC: J19.3 ; also on sheet 11
CPSW_RGMII_INTn: J18.10 J19.10 R344.2 R346.1 R346.2 R620.1 R621.2
EXP1_GPIO0_1: U47.K22(OSPI0_LBCLKO) ; also on sheet 54
EXP1_GPIO0_13: U47.K20(OSPI0_CSN2) ; also on sheet 54
EXP1_GPIO0_14: U47.G20(OSPI0_CSN3) ; also on sheet 54
EXT_VMON2_1: J18.2 TP95.1(TP)
EXT_VMON2_2: J19.2 TP94.1(TP)
GPIO_CPSW1_RST: R364.1 ; also on sheet 55
GPIO_CPSW2_RST: R604.1 ; also on sheet 55
GPIO_OSPI_RSTn: R121.1 U47.G19(OSPI0_CSN1)
I2C_ADDR0_A0: J18.47 R641.1 R642.2
I2C_ADDR0_A2: J18.37 R638.1 R639.2
I2C_ADDR1_A0: J19.47 R628.2 R630.1
I2C_ADDR1_A2: J19.37 R626.2 R629.1
OSPI0_CSN0: R206.2 U47.H21(OSPI0_CSN0)
OSPI_CLK: R197.1 R451.1 U28.B2(CK)
OSPI_CS: R206.1 R447.1 U28.C2(CS#)
OSPI_DQ0: R446.1 RA3.1 U28.D3(DQ0)
OSPI_DQ1: R450.1 RA3.2 U28.D2(DQ1)
OSPI_DQ2: R452.1 RA3.3 U28.C4(DQ2)
OSPI_DQ3: R449.1 RA3.4 U28.D4(DQ3)
OSPI_DQ4: R448.1 RA4.1 U28.D5(DQ4)
OSPI_DQ5: R445.1 RA4.2 U28.E3(DQ5)
OSPI_DQ6: R444.1 RA4.3 U28.E2(DQ6)
OSPI_DQ7: R443.1 RA4.4 U28.E1(DQ7)
OSPI_DQS: R453.1 U28.C3(DS)
OSPI_DQS_SOC: R453.2 R454.1 R504.1 U47.L21(OSPI0_DQS)
OSPI_INTn: R123.1 R125.1
OSPI_RSTn: R124.1 U27.4(Y) U28.A4(RESET#)
PORz_OUT: U68.3(B) U120.3(B) ; also on sheet 10 38 43
RESETSTATz: R366.1 R605.1 U27.2(B) ; also on sheet 5 10 37 38 43 49 55 56
RGMII1_INH: J18.26 R353.2 TP65.1(TP) ; also on sheet 33
RGMII1_RX_ER: J18.39 TP99.1(TP)
RGMII1_RX_LINK: J18.43 R360.2 TP98.1(TP)
RGMII2_INH: J19.26 R354.2 TP59.1(TP) ; also on sheet 33
RGMII2_RX_ER: J19.39 TP89.1(TP)
RGMII2_RX_LINK: J19.43 R347.2 TP91.1(TP)
SoC_I2C0_SCL: J18.40 J19.40 R622.2 R625.1 ; also on sheet 1 3 17 20 22 50 55
SoC_I2C0_SDA: J18.42 J19.42 R616.1 R618.2 ; also on sheet 1 3 17 20 22 50 55
SoC_OSPI_CLK: R197.2 U47.L22(OSPI0_CLK)
SoC_OSPI_DQ0: RA3.8 U47.J21(OSPI0_D0)
SoC_OSPI_DQ1: RA3.7 U47.J18(OSPI0_D1)
SoC_OSPI_DQ2: RA3.6 U47.J19(OSPI0_D2)
SoC_OSPI_DQ3: RA3.5 U47.H18(OSPI0_D3)
SoC_OSPI_DQ4: RA4.8 U47.K21(OSPI0_D4)
SoC_OSPI_DQ5: RA4.7 U47.H19(OSPI0_D5)
SoC_OSPI_DQ6: RA4.6 U47.J20(OSPI0_D6)
SoC_OSPI_DQ7: RA4.5 U47.J22(OSPI0_D7)
SoC_RGMII_MDC: R338.1 R352.1 ; also on sheet 48
SoC_RGMII_MDIO: R340.1 R345.1 ; also on sheet 48
N16956459: R121.2 R122.1 U27.1(A)
N17269599: R363.1 R366.2 U68.6(C)
N17269609: R362.1 R364.2 R367.1 U68.1(A)
N22498870: R602.1 R605.2 U120.6(C)
N22498881: R601.1 R604.2 R606.1 U120.1(A)
N25809420: C610.1 J18.SH1 J18.SH2 J18.SH3 J18.SH4 R623.2
N25815350: C611.1 J19.SH1 J19.SH2 J19.SH3 J19.SH4 R624.2
N27148451: R125.2 U28.A5(INT#)

Not connected (* = marked no-connect by the designer): U28 A2(DNU1) A3(DNU2) B1(DNU3) B5(DNU4) C5(DNU5)

## Notes on the sheets
sheet 39
- OSPI INTERFACE
- SOC OSPI INTERFACE
- Place RA1 & RA2 closer to Memory
- D-Note :
  Recommended 0E provision on
  OSPI0 clock for signal integrity
- D-Note :
  These series resistors are for enabling OSPI
  These are specific to SK and optional if the interface is fixed
- Note: Pullup is DNI
- Place R309 close
  to the Memory
- Place R305 closer
  to the SoC
- Tripad R309
  to avoid stubs
- OSPI  FLASH
- OSPI  FLASH RESET
- D-Note :
  SoC Internal pulls are off during power-up.
  External pullups are recommended near to the attached device
- Silk: OSPI FLASH
- NOTE:
  OSPI NAND Flash can be replaced with the Footprint
  compatible OCTAL NOR Flash (Mfr Part# W35N01JWTBAG)
sheet 40
- ETHERNET EXPANSION CONNECTOR CPSW3G RGMII 1
- I2C Address Strap
- DF40GB-48DP-0.4V(58)
- Silk: ETH0 Connector
- CPSW3G  RGMII 1 RESET
- Note: Verify the resistor mounting
  configuration for resistors that are
  marked as DNI
sheet 41
- ETHERNET EXPANSION CONNECTOR CPSW3G RGMII 2
- I2C Address Strap
- DF40GB-48DP-0.4V(58)
- Silk: ETH1 Connector
- CPSW3G RGMII 2 RESET
- CAD Note: Thevnin's termination should
   be placed at the J19 Connector
- Note: Verify the resistor mounting
  configuration for resistors that are
  marked as DNI
