# OrCAD Capture schematic PROC180E1_SCH.DSN, sheets 48 to 49 of 59

## Sheets
48 19. SOC WKUP & ETH CLK BUFFER: size C; title: SOC WKUP & GPMC
49 38. DIGITAL AUDIO IN_OUT-1: size C; title: AUDIO -  DIGITAL IN & OUT, OPTICAL IN -1

## Parts
sheet 19. SOC WKUP & ETH CLK BUFFER
C182  100pF  [CAP0201_0-5]
C188  100pF  [CAP0201_0-5]
C205  18pF  [CAP0402_0-75]
C209  18pF  [CAP0402_0-75]
C213  12pF  [CAP0402_0-75]
C216  12pF  [CAP0402_0-75]
C245  100pF  [CAP0201_0-5]
C248  100pF  [CAP0201_0-5]
C265  1uF  [CAP0201_0-5]
C266  0.1uF  [CAP0201_0-5]
C284  0.1uF  [CAP0201_0-5]
C286  1uF  [CAP0201_0-5]
C290  10uF  [CAP0402_0-75]
FL10  120E  [EMIFIL_BLM15A_0402_0-6]
R210  62E_1%  [RES0402_0-5]
R216  22E  [RES0201_0-5]
R234  62E_1%  [RES0402_0-5]
R249  0E  [RES0201_0-5]
R252  0E  [RES0201_0-5]
R253  0E  [RES0201_0-5]
R254  0E  [RES0201_0-5]
R256  62E_1%  [RES0402_0-5]
R259  4.7K  [RES0201_0-5]
R261  0E  [RES0201_0-5]
R284  62E_1%  [RES0402_0-5]
R301  4.7K  [RES0201_0-5]
R329  10K  [RES0201_0-5]
R336  22E  [RES0201_0-5]
R337  0E  [RES0201_0-5]
R348  10K  [RES0201_0-5]
R349  22E  [RES0201_0-5]
R358  22E  [RES0201_0-5]
R359  22E  [RES0201_0-5]
R541  0E  [RES0402_0-5]
R548  0E  [RES0402_0-5]
R563  0E  [RES0201_0-5]
R568  1M  [RES0402_0-5]
R570  0E  [RES0201_0-5]
R574  22E  [RES0201_0-5]
R598  4.7K  [RES0201_0-5]
R603  4.7K  [RES0201_0-5]
TP75  TP20_SMD  [TP20_SMD]
U62  25.000MHz  [VSON4_LMK6CE_80X100_SMD_1]
U65  LMK1C1103PWR  [TSSOP8_25-59_125X180_1-2]
Y3  25.000MHz  [XTAL4_XRCGB-FM_80X60_SMD_0-7]
Y4  32.768KHz  [XTAL_ECS-32_130X60_SMD_0-9]
sheet 30. SOC PERIPHERALS 3
U47  XAM62D24AVGHIANF  [FBGA484_31-49_710X710_2-7]  (sections A,B,C,D,E,F,G,H,I,J,K,L,M,N,O,P,Q)
sheet 38. DIGITAL AUDIO IN_OUT-1
C1  0.1uF  [CAP0402_0-75]
C4  0.1uF  [CAP0201_0-5]
C5  0.1uF  [CAP0402_0-75]
C6  0.1uF  [CAP0402_0-75]
C7  0.1uF  [CAP0402_0-75]
C8  0.1uF  [CAP0402_0-75]
C9  10uF  [CAPCT0805H_1]
C10  10uF  [CAP0402_0-75]
C19  0.1uF  [CAP0201_0-5]
C34  0.1uF  [CAP0201_0-5]
C36  10uF  [CAP0402_0-75]
C39  0.1uF  [CAP0201_0-5]
C40  0.1uF  [CAP0201_0-5]
C41  0.1uF  [CAP0201_0-5]
C44  0.1uF  [CAP0201_0-5]
C58  0.1uF  [CAP0201_0-5]
C59  10uF  [CAP0402_0-75]
C79  0.1uF  [CAP0201_0-5]
C80  10uF  [CAP0402_0-75]
C91  10uF  [CAP0402_0-75]
C94  0.1uF  [CAP0402_0-75]
C339  0.1uF  [CAP0402_0-75]
FL3  120E  [EMIFIL_BLM15A_0402_0-6]
FL5  120E  [EMIFIL_BLM15A_0402_0-6]
J5  CON_RCAJACK3_RCJ-022  [CON_RCAJACK3_RCJ-02X_S_S_T_16]
J6  CON_RCAJACK3_RCJ-022  [CON_RCAJACK3_RCJ-02X_S_S_T_16]
L1  47uH  [INDP1210]
MOD1  PLR237/T10BK  [MOD5_PLR135T10_10-3]
R1  75E_1%  [RES0402_0-5]
R2  75E_1%  [RES0402_0-5]
R11  0E  [RES0201_0-5]
R12  10K  [RES0201_0-5]
R13  0E  [RES0201_0-5]
R14  0E  [RES0201_0-5]
R15  0E  [RES0201_0-5]
R16  0E  [RES0201_0-5]
R40  0E  [RES0201_0-5]
R41  0E  [RES0201_0-5]
R42  0E  [RES0201_0-5]
R43  0E  [RES0201_0-5]
R44  0E  [RES0201_0-5]
R45  0E  [RES0201_0-5]
R47  10K  [RES0201_0-5]
R48  10K  [RES0201_0-5]
R49  10K  [RES0201_0-5]
R50  10K  [RES0201_0-5]
R51  0E  [RES0201_0-5]
R52  0E  [RES0201_0-5]
R59  10K  [RES0402_0-5]
R72  10K  [RES0402_0-5]
R79  0E  [RES0201_0-5]
R417  10K  [RES0201_0-5]
R424  10K  [RES0201_0-5]
R425  10K  [RES0201_0-5]
R426  10K  [RES0201_0-5]
R481  0E  [RES0201_0-5]
TP3  TP30_SMD  [TP30_SMD]
TP4  TP30_SMD  [TP30_SMD]
TP7  TP30_SMD  [TP30_SMD]
TP10  TP30_SMD  [TP30_SMD]
TP13  TP30_SMD  [TP30_SMD]
TP15  TP30_SMD  [TP30_SMD]
TP16  TP30_SMD  [TP30_SMD]
TP24  TP30_SMD  [TP30_SMD]
TP28  TP30_SMD  [TP30_SMD]
TP29  TP30_SMD  [TP30_SMD]
TP30  TP30_SMD  [TP30_SMD]
U1  SN74LVC1G125DBVR  [SOT23-5]
U3  DIX4192IPFB  [TQFP48_19-68_280X280_1-2]
U13  SN74LVC1G08DBVRE4  [SOT23-5]

## Library data of the parts
C182 C188 C245 C248 = CAP: CAP CERAMIC 100pF 16V 10% X7R 0201; Chkd/date: PRAVEEN/091222; Crtd /date: PRAVEEN/091222; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-6146-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM033R71C101KA01D; Mistral Part No: 120022120014-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: QUALCOMM_QRB5165_FLIGHT_KIT_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 0.33mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRM033R71C101KA01D.PDF
C205 C209 = CAP: CAP CERAMIC 18pF 50V 5% HI-Q C0G(NP0) 0402; Chkd/date: VASANTHA/030315; Crtd /date: NAVEED/271014; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-3119-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GJM1555C1H180JB01D; Mistral Part No: 120014100019-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: DC_MIST_RDC; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 50V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
C213 C216 = CAP: CAP CERAMIC 12pF 16V 5% C0G(NP0) 0402; Chkd/date: ALVY/090222; Crtd /date: TAMILARASU/080222; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 399-C0402C120J4GAC7867TR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: KEMET; Mfr_part_number: C0402C120J4GACTU; Mistral Part No: 120022020004-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: VANTAGE ROBOTICS_GCS-MB_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: 16V; Wattage: NA; Weight: 1.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\KEMET-C0G_SERIES.PDF
C265 = CAP: CAP CERAMIC 1uF 10V 20% X5R 0201; Chkd/date: NAVEED/070415; Crtd /date: VASANTHA/230314; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 1276-1324-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.35MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: SAMSUNG; Mfr_part_number: CL03A105MP3NSNC; Mistral Part No: 120015030003-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: DUET BOARDS; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\CL03A105MP3NSNC.PDF
C266 C284 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Alt_Mfr_name: YAGEO AMERICA; Alt_Mfr_part_number: CC0402KRX5R8BB104; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 16V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C286 = CAP: CAP CERAMIC 1uF 10V 20% X6S 0201; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C81A105ME13DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.39MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C81A105ME13D; Mistral Part No: 120022060020-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+105°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C81A105ME13D.PDF
C10 C36 C59 C80 C91 C290 = CAP: CAP CERAMIC 10uF 10V 20% X5R 0402; Chkd/date: PRADEEP/130623; Crtd /date: PRADEEP/130623; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRM155R61A106ME18; Mistral Part No: 120022060018-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: AM62P_SK; RoHS: RoHS; Temperature: -55°C+85°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 6mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\MURATA-GXX-SER_NOV17.PDF
FL3 FL5 FL10 = EMIFILTER_IND: IND FERRITE BEAD CHIP 120E 2A 0402; Chkd/date: MANIRAJA/311221; Crtd /date: ALVY/301221; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_FILTER_Library.schlib; Mfr_name: MURATA; Mfr_part_number: BLM15PX121SZ1B; Mistral Part No: 130021120017-R; Package: 0402; Part_type: INDUCTOR; Project: AM62Q_SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 25%; Voltage: NA; Wattage: NA; Weight: 1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\BLM-SER.PDF
R210 R234 R256 R284 = RESISTOR: RES 62E 1/10W 1% 0402; Chkd/date: MANIRAJA/160318; Crtd /date: BAVISH/020611; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P62.0LCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF62R0X; Mistral Part No: 110011060013-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AM4515_EVM_LCD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R216 R336 R349 R358 R359 R574 = RESISTOR: RES 22E 1/20W 5% 0201; Chkd/date: ALVY/210122; Crtd /date: TAMILARASU/210122; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 541-22AGCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.28MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: VISHAY; Mfr_part_number: CRCW020122R0JNED; Mistral Part No: 110022010021-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: DLRL DIGITAL RECEIVER_BRD; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\CRCW0201.PDF
R11 R13-R16 R40-R45 R51 R52 R79 R249 R252-R254 R337 R481 R563 R570 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R259 R301 R598 R603 = RESISTOR: RES 4.7K 1/20W 5% 0201; Chkd/date: MANIRAJA/200921; Crtd /date: ALVY/200921; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-4.7KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-074K7L; Mistral Part No: 110021090007-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: TI_AM62x SKEVM_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R261 = RESISTOR: RES 0E 1/20W 5% 0201; Chkd/date: NAVEED/301214; Crtd /date: MUDDU/120710; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-0.0NCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-070RL; Mistral Part No: 110010070067-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: PB_BUGBASE; RoHS: RoHS; SIGNAL_MODEL: RESISTOR_RES0201_0-5_0E_0E; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R12 R47-R50 R329 R348 R417 R424-R426 = RESISTOR: RES 10K 1/20W 5% 0201; Chkd/date: MANIRAJA/050517; Crtd /date: MANIRAJA/050517; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KNCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.26MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0201JR-0710KL; Mistral Part No: 110010070051-R; Package: 0201; Part_type: RESISTORS\FIXED; Project: GOLDEN-I LITE; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 5%; Voltage: NA; Wattage: 1/20W; Weight: 0.17mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
R541 R548 = RESISTOR: RES 0E 1/10W JUMPER 0402; Chkd/date: VASANTHA/061216; Crtd /date: NAVEED/201014; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P0.0JCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; IBISSP_MODLES: VALUE REPEATING 2 TIME; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2GE0R00X; Mistral Part No: 110018030052-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AEGIS POM; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: NA; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R568 = RESISTOR: RES 1M 1/16W 5% 0402; Chkd/date: SHREESHAIL/061205; Crtd /date: SHREESHAIL/231105; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-1.0MJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-071ML; Mistral Part No: 110009030415-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: ADR; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP75 = TESTPOINT: TESTPOINT CIR 20 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: NA; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U62 = OSC4_LMK6CE: OSC 25.00MHz LOW JITTER HIGH-PERFORMANCE BAW VSON4; Chkd/date: PRAVEEN/170423; Crtd /date: TAMILARASU/170423; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: NA; Distributor_part_number: NA; Height: 1.00MM; Mfr_name: TEXAS INSTRUMENTS; Mfr_part_number: LMK6CE025000DDLFT; Mistral Part No: 130023040014-R; Package: VSON4; Part_type: OSCILLATORS; Project: AM62P_SK; RoHS: RoHS; Temperature: -40°C+105°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\LMK61XXX-SER.PDF
U65 = LMK1C1103_TSSOP8: IC 3-CHANNEL LVCMOS CLOCK BUFFER TSSOP8; Chkd/date: MANIRAJA/080920; Crtd /date: ALVY/070920; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-LMK1C1103PWRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.20MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_COMBINATIONAL_Library.schlib; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141020090002-R; Package: TSSOP8; Part_type: ICS\DIGITAL\COMBINATIONAL; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 34.1mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\COMBINATIONAL\LMK1C110X.PDF
Y3 = CRY4_13: CRY 25.000MHz 6pF SMD; Chkd/date: MANIRAJA/151020; Crtd /date: ALVY/151020; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: 490-5578-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.70MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: XRCGB25M000F3M00R0; Mistral Part No: 130020100043-R; Package: SMD; Part_type: CRYSTAL; Project: AM64X_SKEVM; RoHS: RoHS; Temperature: -30°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 23mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\XRCGB.PDF
Y4 = CRY: CRY 32.768KHz 9pF SMD; Chkd/date: VASANTHA/090419; Crtd /date: ALVY/090419; Custom_Duty: 24%; Customs_HS_Code: 85439000; Distributor_name: DIGIKEY; Distributor_part_number: XC2160CT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.90MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: ECS INC; Mfr_part_number: ECS-.327-9-34QCS-TR; Mistral Part No: 130019040003-R; Package: SMD; Part_type: CRYSTAL; Project: J7ES_SOM_DUAL-LEO_PMIC; RoHS: RoHS; Temperature: -40°C+125°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 16mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\MISC\CRY_OSC\ECS-34Q.PDF
U47 = AM62D_EVM_SOC_FCBGA484: IC AM62D EVM SoC MICROPROCESSOR FCBGA484; Chkd/date: PRADEEP/010424; Crtd /date: PRADEEP/010424; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 2.65MM; Library Ref: AM62D_EVM_SoC_FCBGA484; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141224040001-R; Package: FCBGA484; Part_type: ICS\DIGITAL\MICROPROCESSOR; Project: AM62D_EVM; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\MICROCONTROLLER\AM62A_SK_EVM.PDF
C1 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R 0402; Chkd/date: VASANTHA/281216; Crtd /date: CHAITHANYA/051011; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 445-173610-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.60MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: TDK CORPORATION; Mfr_part_number: C1005X7R1H104K050BE; Mistral Part No: 120011100014-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: VP-4000-BASE-BOARD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 10V; Wattage: NA; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\TDK_C-SER_FEB19.PDF
C4 C19 C34 C39-C41 C44 C58 C79 = CAP: CAP CERAMIC 0.1uF 16V 10% X7S AUTO 0201; Chkd/date: MANIRAJA/110321; Crtd /date: ALVY/110321; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 490-GRT033C71C104KE01DTR-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.33MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT033C71C104KE01D; Mistral Part No: 120021030007-R; Package: 0201; Part_type: CAPACITORS\CERAMIC; Project: J7ES_SK_BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 10V; Wattage: NA; Weight: 330mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT033C71C104KE01.PDF
C5-C8 C339 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
C9 = CAP_POL: CAP TANTALUM 10uF 10V 20% ESR 5E H0805; Chkd/date: MANIRAJA/091018; Crtd /date: ALVY/091018; Custom_Duty: 15%; Customs_HS_Code: 85322990; Distributor_name: DIGIKEY; Distributor_part_number: 478-11046-1-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 1.00MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: AVX CORPORATION; Mfr_part_number: TACH106M010XTA; Mistral Part No: 120018100018-R; Package: H0805; Part_type: CAPACITORS\TANTALUM; Project: TI_J7ES_EVM_CP; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 20%; Voltage: 10V; Wattage: NA; Weight: 5.5mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\AVX-TAC-APR18.PDF
C94 = CAP: CAP CERAMIC 0.1uF 50V 10% X7R AUTO 0402; Automotive Alternate_mfr_name: TDK; Automotive Alternate_mfr_part_number: CGA2B3X7R1H104K050BB; Chkd/date: MANIRAJA/250221; Crtd /date: ALVY/240221; Custom_Duty: 15%; Customs_HS_Code: 85322990; Direct Alternate_mfr_name: TDK; Direct Alternate_mfr_part_number: C1005X7R1H104K050BE; Distributor_name: MOUSER; Distributor_part_number: 81-GRT155R71H104KE1D; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.55MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: MURATA; Mfr_part_number: GRT155R71H104KE01D; Mistral Part No: 120019030005-R; Package: 0402; Part_type: CAPACITORS\CERAMIC; Project: TI_DRA821 SK EVM BRD; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: 10V; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CAPACITORS\GRT155R71H104KE01.PDF
J5 = CON_RCAJACK3_RCJ-02X: CON RCAJACK 3POS FEMALE ST TH; Chkd/date: MANIRAJA/091118; Crtd /date: MANIRAJA/091118; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: CP-1406-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 15.95MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: CUI; Mfr_part_number: RCJ-021; Mistral Part No: 150018110010-R; Package: THRU-HOLE; Part_type: CONNECTOR\JACK; Project: TI_J7ES_EVM_IB; RoHS: RoHS; Temperature: -20°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 2000mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\RCJ-02X.PDF
J6 = CON_RCAJACK3_RCJ-02X: CON RCAJACK 3POS FEMALE ST TH; Chkd/date: MANIRAJA/091118; Crtd /date: MANIRAJA/091118; Custom_Duty: 24%; Customs_HS_Code: 85369090; Distributor_name: DIGIKEY; Distributor_part_number: CP-1407-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 15.95MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_CONNECTOR_Library.schlib; Mfr_name: CUI; Mfr_part_number: RCJ-022; Mistral Part No: 150018110009-R; Package: THRU-HOLE; Part_type: CONNECTOR\JACK; Project: TI_J7ES_EVM_IB; RoHS: RoHS; Temperature: -20°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: 2000mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\RCJ-02X.PDF
L1 = INDUCTOR: IND 47uH 170mA 10% 1210; Chkd/date: NAVEED/180814; Crtd /date: VASANTHA/230614; Custom_Duty: 24%; Customs_HS_Code: 85437099; Distributor_name: DIGIKEY; Distributor_part_number: 490-4063-1-ND; Height: 1.70MM; Mfr_name: MURATA; Mfr_part_number: LQH32CN470K53L; Mistral Part No: 130014060042-R; Package: 1210; Project: ASIO; RoHS: RoHS; Temperature: -55°C+125°C; Tolerance: 10%; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\DISCRETES\INDUCTORS\MURATA-LQH.PDF
MOD1 = MODULE_PLR135T10: MODULE FIBER OPTIC RECEIVER TH; Chkd/date: PRADEEP/040124; Crtd /date: TAMILARASU/040124; Custom_Duty: 15%; Customs_HS_Code: 85412900; Distributor_name: DIGIKEY; Distributor_part_number: 1080-PLR237/T10BK-ND; Height: 10.30MM; Mfr_name: EVERLIGHT ELECTRONICS; Mistral Part No: 180024010001-R; Package: THRU-HOLE; Part_type: MODULE; Project: AM62D_EVM; RoHS: RoHS; Temperature: 20°C+70°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\CONNECTORS\PLR237-T10BK.PDF
R1 R2 = RESISTOR: RES 75E 1/10W 1% 0402; Chkd/date: USMAN/161111; Crtd /date: CHAITHANYA/151111; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: P75.0LCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: PANASONIC-ECG; Mfr_part_number: ERJ-2RKF75R0X; Mistral Part No: 110011110029-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: AVCDP1; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 1%; Voltage: NA; Wattage: 1/10W; Weight: 0.8mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\PAN-ERJSER_NOV17.PDF
R59 R72 = RESISTOR: RES 10K 1/16W 5% 0402; Chkd/date: VASANTHA/061216; Crtd /date: MAZHAR/230805; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 311-10KJRCT-ND; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: 0.40MM; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; Mfr_name: YAGEO AMERICA; Mfr_part_number: RC0402JR-0710KL; Mistral Part No: 110011060021-R; Package: 0402; Part_type: RESISTORS\FIXED; Project: HSE; RoHS: RoHS; Temperature: -55°C+155°C; Tolerance: 5%; Voltage: NA; Wattage: 1/16W; Weight: 0.65mg; Datasheet: Y:\MIS_DATABASE\DATASHEETS\RESISTORS\RCXXXXL-SER_MAR18.PDF
TP3 TP4 TP7 TP10 TP13 TP15 TP16 TP24 TP28-TP30 = TESTPOINT: TESTPOINT CIR 30 SMD; Chkd/date: SHREESHAIL/171006; Crtd /date: MAZHAR/171006; Custom_Duty: NA; Customs_HS_Code: NA; Distributor_name: NA; Distributor_part_number: NA; Footprint Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\PCB_FOOTPRINTS\Altium_Footprint_Lib.PcbLib; Height: NA; Library Path: Y:\MIS_DATABASE\Library\ALTIUM_TOOL\SCHEMATICS_PARTS\MS_DISCRETE_Library.schlib; MECHANICAL 3D STEP FILE: NA; Mfr_name: LOCAL; Mistral Part No: 130009030930; Package: SMD; Project: BT MODULE_CSRBC04; RoHS: NA; Temperature: NA; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: NA
U1 = SN74LVC1G125_SOT23-5: IC SINGLE BUS BUFFER GATE SOT23-5; Chkd/date: BAVISH/161111; Crtd /date: CHAITHANYA/071111; Custom_Duty: 15%; Customs_HS_Code: 85332119; Distributor_name: DIGIKEY; Distributor_part_number: 296-11603-1-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141011110003-R; Part_type: ICS\DIGITAL\GATES; Project: NA10NG; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\TEXAS-SN74LVC1G125.PDF
U3 = DIX4192IPFB_TQFP48: IC  INTEGRATED DIGITAL AUDIO INTERFACE RECEIVER AND TRANSMITTER TQFP48; Chkd/date: PRADEEP/220923; Crtd /date: TAMILARASU/221123; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: 296-41504-ND; Height: 1.20MM; MECHANICAL 3D STEP FILE: TQFP48_19-68_280X280_1-1; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 143023110001-R; Package: TQFP48; Part_type: ICS\TELECOM\TRANSCEIVER; Project: AM62D_EVM; RoHS: RoHS; Temperature: -40°C+85°C; Tolerance: NA; Voltage: NA; Wattage: NA; Weight: NA; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\TELECOM\DIX4192.PDF
U13 = SN74LVC1G08DBVRE4_SOT23-5: IC SINGLE 2-INPUT POSITIVE AND GATE SOT23-5; Automotive Alternate_mfr_name: TEXAS INSTRUMENTS; Automotive Alternate_mfr_part_number: SN74LVC1G08QDBVRQ1; Chkd/date: SUHAS/221010; Crtd /date: USMAN/151008; Custom_Duty: 15%; Customs_HS_Code: 85423100; Distributor_name: DIGIKEY; Distributor_part_number: SN74LVC1G08DBVRE4-ND; Height: 1.45MM; Mfr_name: TEXAS INSTRUMENTS; Mistral Part No: 141009060026-R; Part_type: ICS\DIGITAL\GATES; Project: KHAN_MAIN; RoHS: Sb/ Br FREE; Temperature: -40°C+85°C; Datasheet: Y:\MIS_DATABASE\DATASHEETS\ICS\DIGITAL\GATES\SN74LVC1G08.PDF

## Nets
DGND: C1.2 C4.2 C6.2 C7.2 C9.2 C10.2 C19.2 C34.2 C36.2 C39.2 C40.2 C41.2 C44.2 C58.2 C59.2 C79.2 C80.2 C91.2 C94.2 C182.2 C188.2 C205.1 C209.1 C213.1 C216.1 C245.2 C248.2 C265.2 C266.1 C284.1 C286.1 C290.2 C339.2 J5.1 J5.3 J6.1 J6.3 MOD1.2(GND) R1.2 R2.2 R48.2 R49.2 R254.1 R417.1 R426.2 U1.3(GND) U3.10(AGND) U3.16(DGND1) U3.30(DGND2) U3.43(DGND3) U3.44(BGND) U13.3(GND) U62.2(GND) U65.4(GND) Y3.2 Y3.4 ; also on sheet 1 2 3 4 5 6 7 8 9 10 12 13 14 16 17 18 19 20 21 22 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 50 51 52 53 54 55 56 57 58
V3V3_OPTICAL: C1.1 L1.2 MOD1.1(VCC)
VCC1V8_CLKBUF: C265.1 C266.2 C284.2 C286.2 FL10.1 R329.2 R348.2 U62.4(VDD) U65.6(VDD)
VCC1V8_SYS: FL5.1 ; also on sheet 1 2 4 6 7 10 20 21 22 33 37 38 39 43 50 52 53 54 55 56 57 58
VCC1V8_VDD18: C10.1 C19.1 C79.1 C80.1 C91.1 C94.1 FL5.2 R47.1 R50.1 R59.2 R72.2 R424.2 R425.2 U3.17(VDD18) U3.42(VIO) U13.5(VCC) ; also on sheet 1
VCC_3V3_SYS: FL3.1 R259.1 R301.1 R598.1 R603.1 ; also on sheet 1 2 3 6 10 14 17 18 19 20 22 31 33 37 38 40 41 42 45 46 50 51 52 53 54 55 56 57 58
VDDA1V8: C290.1 FL10.2 ; also on sheet 33
CLKOUT0: R336.2 R337.2 U65.1(CLKIN)
CLKOUT_OSC: R336.1 U62.3(OUT)
CPSW_RGMII1_ETH1_CLK: R359.2 ; also on sheet 40
CPSW_RGMII2_ETH2_CLK: R358.2 ; also on sheet 41
DIX4192_McASP0_ACLKR: R481.2 ; also on sheet 20
DIX4192_McASP0_ACLKX: R14.2 ; also on sheet 1
DIX4192_McASP0_AFSR: R11.2 ; also on sheet 20
DIX4192_McASP0_AFSX: R15.2 ; also on sheet 20
DIX4192_McASP0_AXR0: R16.2 ; also on sheet 20
DIX4192_McASP0_AXR1: R13.2 ; also on sheet 1
DIX_3V3_SYS: C9.1 C36.1 C39.1 C58.1 C59.1 C339.1 FL3.2 L1.1 R12.1 U1.5(VCC) U3.9(VCC) U3.33(VDD33)
DIX_ADDR0: R40.2 R49.1 R50.2
DIX_ADDR1: R43.2 R47.2 R48.1
DIX_BLS: R417.2 U3.35(BLS)
DIX_INT_1V8: R424.1 U3.23(~{INT}) ; also on sheet 55
DIX_MCLK: U3.25(MCLK) ; also on sheet 22
DIX_OP_IN_N: C4.1 U3.8(RX4-)
DIX_OP_IN_P: U1.4(Y) U3.7(RX4+)
DIX_RESETn: R59.1 U3.24(~{RST}) U13.4(Y)
DIX_RVD_CLK: U3.12(RXCKO) ; also on sheet 22
DIX_RX1: C8.2 J5.2 R1.1
DIX_RX1_N: C7.1 U3.2(RX1-)
DIX_RX1_P: C8.1 U3.1(RX1+)
DIX_RX2_N: C40.1 U3.4(RX2-)
DIX_RX2_P: C34.1 U3.3(RX2+)
DIX_RX3_N: C44.1 U3.6(RX3-)
DIX_RX3_P: C41.1 U3.5(RX3+)
DIX_TX: C5.2 J6.2 R2.1
DIX_TX_N: C6.1 U3.31(TX-)
DIX_TX_P: C5.1 U3.32(TX+)
EXP2_MCU_SPI1_CS2: R563.1 ; also on sheet 54
EXT_CLKOUT0: R337.1 ; also on sheet 7
GPIO_DIX_RST: R79.1 ; also on sheet 55
GPIO_MCU_SoC_INTn: R563.2 U47.B9(MCU_MCAN1_RX) ; also on sheet 57
IO_EXP_OPT_EN: R12.2 U1.1(~{OE}) ; also on sheet 55
McASP0_ACLKR_R: R481.1 U3.48(BCKB)
McASP0_ACLKX_R: R14.1 U3.37(BCKA)
McASP0_AFSR_R: R11.1 U3.47(LRCKB)
McASP0_AFSX_R: R15.1 U3.38(LRCKA)
McASP0_AXR0_R: R16.1 U3.45(SDOUTB)
McASP0_AXR1_R: R13.1 U3.39(SDINA)
MCU_I2C0_SCL: C188.1 R234.1 R598.2 ; also on sheet 33
MCU_I2C0_SDA: C182.1 R210.1 R603.2 ; also on sheet 33
MCU_INTn: U47.B10(WKUP_CLKOUT0) ; also on sheet 33
MCU_MCAN0_RX: U47.E8(MCU_MCAN0_RX) ; also on sheet 58
MCU_MCAN0_TX: U47.C7(MCU_MCAN0_TX) ; also on sheet 58
MCU_OSC0_XI: R249.2 R252.2 U47.A12(MCU_OSC0_XI)
MCU_OSC0_XO: R253.2 R254.2 U47.A11(MCU_OSC0_XO)
MCU_SPI0_CLK: R216.2 ; also on sheet 54
MCU_SPI0_CS0: U47.E11(MCU_SPI0_CS0) ; also on sheet 54
MCU_SPI0_D0: U47.A15(MCU_SPI0_D0) ; also on sheet 54
MCU_SPI0_D1: U47.B12(MCU_SPI0_D1) ; also on sheet 54
MCU_SPI1_CLK: R574.2 ; also on sheet 6
MCU_SPI1_CS0: U47.C10(WKUP_UART0_CTSN) ; also on sheet 6
MCU_SPI1_D0: U47.B11(MCU_UART0_CTSN) ; also on sheet 6
MCU_SPI1_D1: U47.D10(MCU_UART0_RTSN) ; also on sheet 6
MCU_TIMER_IO1: U47.C11(MCU_SPI0_CS1) ; also on sheet 54
MCU_TIMER_IO2: R570.1 ; also on sheet 54
MCU_UART0_RX_3V3: U47.D8(MCU_UART0_RXD) ; also on sheet 4
MCU_UART0_TX_3V3: U47.F8(MCU_UART0_TXD) ; also on sheet 4
MODE_SELECT: R425.1 R426.1 U3.18(CPM)
OPT_RX: MOD1.3(VOUT) U1.2(A)
PMIC_LPM_EN0: TP75.1(TP) U47.D12(PMIC_LPM_EN0) ; also on sheet 33
RESETSTATz: U13.2(B) ; also on sheet 5 10 37 38 39 40 41 43 55 56
RXCKI: U3.13(RXCKI) ; also on sheet 1
SoC_CLKIN: R249.1 R349.2
SoC_I2C0_SCL_1V8: R51.2 ; also on sheet 1 5 7 21 50 53 56
SoC_I2C0_SDA_1V8: R45.2 ; also on sheet 1 5 7 21 50 53 56
SoC_RGMII_MDC: R548.2 ; also on sheet 40 41
SoC_RGMII_MDIO: R541.2 ; also on sheet 40 41
WKUP_I2C0_SCL: C245.1 R284.1 R301.2 ; also on sheet 33
WKUP_I2C0_SCL_RC: R284.2 U47.D13(WKUP_I2C0_SCL)
WKUP_I2C0_SDA: C248.1 R256.1 R259.2 ; also on sheet 33
WKUP_I2C0_SDA_RC: R256.2 U47.E13(WKUP_I2C0_SDA)
WKUP_LFOSCO_XI: C216.2 R568.1 U47.A8(WKUP_LFOSC0_XI) Y4.1
WKUP_LFOSCO_XO: C213.2 R261.2 R568.2 Y4.2
WKUP_UART0_RX_3V3: U47.C9(WKUP_UART0_RXD) ; also on sheet 4
WKUP_UART0_TX_3V3: U47.E9(WKUP_UART0_TXD) ; also on sheet 4
N21761024: R261.1 U47.A9(WKUP_LFOSC0_XO)
N21784165: R548.1 U47.V12(MDIO0_MDC)
N21784176: R541.1 U47.V13(MDIO0_MDIO)
N24612310: R40.1 R41.1 U3.19(~{CS}/A0)
N24612323: R42.1 R43.1 U3.21(CDIN/A1)
N24612337: R42.2 TP30.1(TP)
N24612352: R41.2 TP28.1(TP)
N24612373: R44.1 R45.1 U3.22(CDOUT/SDA)
N24612400: R44.2 TP24.1(TP)
N24612414: TP4.1(TP) U3.34(AESOUT)
N24612459: TP16.1(TP) U3.11(~{LOCK})
N24612593: R52.2 TP29.1(TP)
N24612656: TP13.1(TP) U3.27(GPO2)
N24612672: TP10.1(TP) U3.28(GPO3)
N24612674: TP7.1(TP) U3.29(GPO4)
N24612683: TP15.1(TP) U3.26(GPO1)
N24612758: R51.1 R52.1 U3.20(CCLK/SCL)
N24612803: TP3.1(TP) U3.36(SYNC)
N24614507: R72.1 R79.2 U13.1(A)
N26609186: R574.1 U47.C8(WKUP_UART0_RTSN)
N27128284: R329.1 U62.1(OE/NC)
N27128639: R348.1 U65.2(1G)
N27128753: R349.1 U65.3(Y0)
N27128755: R358.1 U65.5(Y2)
N27128757: R359.1 U65.8(Y1)
N27283175: R234.2 U47.E12(MCU_I2C0_SCL)
N27283177: R210.2 U47.D9(MCU_I2C0_SDA)
N27283214: C205.2 R252.1 Y3.1
N27283220: C209.2 R253.1 Y3.3
N27283414: R570.2 U47.D7(MCU_MCAN1_TX)
N27283542: R216.1 U47.B13(MCU_SPI0_CLK)

Not connected (* = marked no-connect by the designer): MOD1 4(NC1)* 5(NC2)*; U3 14(NC1)* 15(NC2)* 40(SDOUTA)* 41(NC3)* 46(SDINB)*; U65 7(NC)*

## Notes on the sheets
sheet 48
- SOC - MCU DOMAIN
- SOC WKUP DOMAIN
- ECS-.327-9-34QCS-TR
- $:R74 TRI-PAD WITH R77
- OSCILLATOR
- SOC & ETHERNET PHY CLOCK BUFFER
- DNI
- 25Mhz XTAL
- MCU_OSC0_XI
- EXT_REFCLK1
- DNI
- ETH1
- 1:3 CLK BUFF
- ETH2
- 25Mhz Osc
sheet 49
- AUDIO -  DIGITAL IN & OUT, OPTICAL IN -1
- DIR: FIBER OPTIC RECEIVER MODULE
- Tantalum capacitor
- DIX Supply & Decaps
- I2C ADDRESS: 0xE2
- DEVICE STRAP
- DIX4192 RESET
- DIT & DIR COAXIAL INPUT
- Silk: DIT
- Silk: DIR
- It should be connected to PORz of the SoC TBD
